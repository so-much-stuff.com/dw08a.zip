# EAGLE board dw08a (EAGLE 4.11), part 3 of 3
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
P_DATA03  (via drill 0.61) (continued)
  Bottom 0.305: v67.56,15.24 57.15,25.65 45.47,25.65 43.69,27.43 42.67,27.43 34.04,36.07 30.73,36.07 B22.L2 | v172.21,78.49 172.72,78.49 173.48,77.72 176.28,77.72 177.29,76.71 179.83,76.71 v185.67,70.87 | v251.21,45.72 251.21,45.97 246.13,51.05 242.32,51.05 213.87,79.5 v208.79,79.5 211.84,76.45 v213.61,76.45
P_DATA04  (via drill 0.61)
  Top 0.305: v117.35,89.15 104.9,76.71 104.39,76.71 87.88,60.2 83.57,60.2 42.16,18.8 35.81,18.8 34.54,17.53 28.7,23.37 28.7,24.38 29.72,25.4 29.72,29.46 B22.N2 | v262.64,50.8 262.38,50.55 258.06,50.55 252.98,45.47 252.98,43.43 B05.J1
  2 0.305: v117.35,89.15 118.87,89.15 124.71,95 130.05,95 156.21,121.16 157.23,121.16 v157.48,121.41 159.77,123.7 164.08,123.7 166.37,125.98 168.4,125.98 178.82,136.4 193.55,136.4 193.8,136.65 195.33,136.65 v199.39,140.72 | v262.64,50.8 259.08,50.8 254.51,55.37 253.49,54.36 252.98,54.36 252.73,54.1 240.28,54.1 237.24,51.05 235.46,51.05 v234.95,50.55
  15 0.305: v199.39,140.72 208.28,140.72 215.14,133.86 216.66,133.86 220.22,130.3 231.9,130.3 232.92,129.29 232.92,128.78 239.01,122.68 240.54,122.68 248.67,114.55 250.19,114.55 251.71,113.03 A05.J1 | v234.95,50.55 234.95,51.56 231.65,54.86 229.62,54.86 227.58,56.9 223.52,56.9 215.14,65.28 213.87,65.28 v210.57,68.58
  Bottom 0.305: v210.57,68.58 200.66,78.49 200.66,78.99 189.48,90.17 189.48,91.19 167.39,113.28 165.61,113.28 v157.48,121.41
P_DATA05  (via drill 0.61)
  Top 0.305: v102.11,11.18 104.14,9.14 106.68,9.14 111,13.46 113.03,13.46 115.32,15.75 120.4,15.75 137.41,32.77 138.68,32.77 140.72,34.8 151.13,34.8 158.5,42.16 158.5,47.75 161.04,50.29 162.56,50.29 v164.34,52.07 | v234.95,72.9 233.43,72.9 229.87,69.34 229.87,68.83 210.82,49.78 210.82,48.01 v209.04,46.23
  2 0.305: v197.1,32.26 198.37,30.99 199.9,32.51 201.93,32.51 204.22,34.8 217.17,34.8 | 217.17,34.8 234.7,34.8 235.97,36.07 237.24,36.07 242.32,41.15 246.13,41.15 247.4,39.88 248.67,41.15 249.68,41.15 252.98,37.85 252.22,37.08 B05.L1 | v250.19,107.7 248.67,107.7 248.16,107.19 248.16,106.43 240.28,98.55 239.01,98.55 236.98,100.58 234.19,97.79 233.17,97.79 230.89,95.5 226.82,95.5 v221.49,90.17 | v217.17,36.58 217.17,34.8
  15 0.305: v102.11,11.18 100.33,12.95 89.92,12.95 86.87,16 74.17,16 71.63,18.54 70.61,18.54 69.85,19.3 64.52,19.3 61.47,22.35 36.07,22.35 35.05,23.37 30.73,23.37 B22.R2 | v250.19,107.7 251.21,106.68 251.71,106.68 A05.L1 | v221.49,90.17 221.49,89.92 225.04,86.36 225.04,84.84 228.35,81.53 228.35,79.5 v234.95,72.9 | v209.04,46.23 208.28,45.47 v217.17,36.58
  Bottom 0.305: v164.34,52.07 165.1,52.07 166.12,51.05 172.47,51.05 188.47,35.05 194.31,35.05 v197.1,32.26
P_DATA06  (via drill 0.61)
  Top 0.305: v249.43,62.99 247.4,65.02 247.9,65.53 247.9,65.79 259.59,77.47 263.65,77.47 268.22,82.04 270.51,82.04 272.54,84.07 v272.8,84.07
  2 0.305: v226.31,103.12 227.33,103.12 233.17,108.97 233.93,108.97 235.97,111 v239.78,111 | v255.52,41.4 255.78,41.66 257.05,40.39 257.05,39.12 256.03,38.1 256.03,34.04 B05.M1
  15 0.305: v160.02,127 197.1,127 207.26,116.84 208.28,116.84 216.92,108.2 221.23,108.2 v226.31,103.12 | v239.78,111 246.38,111 247.9,112.52 v249.17,111.25 | v255.52,41.4 255.52,42.93 254.76,43.69 254.76,44.96 247.9,51.82 247.9,58.93 247.14,59.69 247.14,60.71 v249.43,62.99
  Bottom 0.305: v160.02,127 159.77,127.25 147.07,127.25 141.48,132.84 140.46,132.84 139.7,133.6 121.67,133.6 111.76,143.51 90.68,143.51 58.42,111.25 55.12,111.25 48.77,117.6 42.42,117.6 39.12,120.9 32.77,120.9 30.48,123.19 29.46,123.19 24.38,128.27 12.95,116.84 12.95,64.52 15.24,62.23 15.24,61.21 17.02,59.44 17.02,56.13 B23.D2 | v249.17,111.25 249.43,111.25 250.7,109.98 250.7,108.71 251.21,108.2 251.21,107.19 250.44,106.43 251.97,104.9 253.75,104.9 255.02,103.63 A05.M1 256.03,102.62 257.3,101.35 257.3,99.57 v272.8,84.07
P_DATA07  (via drill 0.61)
  Top 0.305: v158.75,5.08 176.02,5.08 177.8,3.3 193.8,19.3 193.8,19.56 v194.82,20.57
  2 0.305: v158.75,5.08 158.5,4.83 157.23,4.83 156.72,4.32 147.32,4.32 145.29,2.29 140.46,2.29 139.19,1.02 70.1,1.02 22.35,48.77 18.03,48.77 B23.F2 | v194.82,20.57 196.34,20.57 197.87,22.1 203.2,22.1 203.96,22.86 204.98,22.86 207.26,25.15 217.93,25.15 v219.2,26.42 | v243.59,16 246.63,16 253.75,23.11 253.75,25.15 B05.P1
  15 0.305: v282.19,12.7 287.78,12.7 305.56,30.48 305.31,30.73 305.31,32.51 305.05,32.77 305.05,34.04 307.09,36.07 307.09,37.08 301.75,42.42 301.75,55.12 290.07,66.8 289.56,66.8 v289.31,67.06 | v274.83,78.49 274.83,78.99 273.3,80.52 273.3,81.03 259.33,95 257.81,95 256.29,96.52 A05.P1 | v219.2,26.42 222.5,26.42 223.27,25.65 227.08,25.65 228.85,23.88 231.14,23.88 235.71,19.3 240.28,19.3 v243.59,16
  Bottom 0.305: v282.19,12.7 279.15,9.65 277.37,9.65 265.43,21.59 264.41,21.59 262.38,23.62 261.11,23.62 258.06,26.67 256.29,26.67 B05.P1 | v289.31,67.06 286.26,67.06 v274.83,78.49
P_DATA08  (via drill 0.61)
  Top 0.305: v12.7,33.78 17.02,38.1 17.02,42.16 B23.J2 | v88.14,3.81 146.81,3.81 147.32,4.32 149.35,4.32 v151.38,6.35 | v198.12,5.08 205.23,5.08 211.58,11.43 211.58,11.94 v214.38,14.73 | v231.9,113.54 231.9,113.28 219.2,100.58 219.2,96.52 218.19,95.5 211.84,95.5 v211.58,95.25
  2 0.305: v151.38,6.35 159.26,6.35 160.78,4.83 197.87,4.83 v198.12,5.08 | v228.09,7.62 243.59,7.62 245.11,9.14 246.13,9.14 253.75,16.76 253.75,18.8 B05.S1 | v211.58,95.25 208.53,92.2 206.25,92.2 202.18,96.27 182.63,76.71 182.63,76.45 178.05,71.88 177.04,71.88 176.78,71.63 175.26,71.63 v148.08,44.45
  Bottom 0.305: v12.7,33.78 12.7,25.65 18.03,20.32 19.05,20.32 29.72,9.65 30.73,9.65 33.53,6.86 74.68,6.86 74.93,6.6 85.34,6.6 v88.14,3.81 | v214.38,14.73 215.14,14.73 220.22,9.65 224.54,9.65 226.06,8.13 227.58,8.13 v228.09,7.62 | v231.9,113.54 231.9,112.27 236.22,107.95 236.22,107.44 241.05,102.62 241.55,102.62 253.24,90.93 255.02,90.93 A05.S1 | v148.08,44.45 148.08,43.69 172.47,19.3 177.8,19.3 178.56,18.54 179.58,18.54 182.12,16 187.2,16 v198.12,5.08
P_DATA09  (via drill 0.61)
  Top 0.305: v77.72,8.38 88.9,8.38 99.31,18.8 111,18.8 130.81,38.61 131.83,38.61 134.37,41.15 137.67,41.15 v139.45,39.37 | v165.1,23.88 167.89,23.88 172.47,28.45 178.82,28.45 188.21,37.85 v190.5,37.85 | v231.14,53.85 233.68,53.85 238,58.17 238,62.23 239.01,63.25 241.81,63.25 245.62,59.44 245.11,58.93 245.11,56.64 245.62,56.13 B05.D2 | v212.85,94.49 212.85,88.9 v210.31,86.36
  2 0.305: v190.5,37.85 194.56,37.85 197.87,41.15 204.22,41.15 207.26,44.2 212.6,44.2 213.36,44.96 214.38,44.96 219.96,50.55 224.03,50.55 v227.33,53.85 | v212.85,94.49 212.85,97.03 212.34,97.54 212.34,99.06 212.85,99.57 212.85,100.58 229.87,117.6 233.93,117.6 239.01,122.68 240.03,122.68 242.32,124.97 245.36,124.97 A05.D2
  15 0.305: v210.31,86.36 210.31,85.6 209.55,84.84 209.55,83.82 210.57,82.8 214.38,82.8 225.3,71.88 227.58,71.88 228.6,70.87 230.38,70.87 231.9,69.34 231.9,67.82 235.97,63.75 235.97,61.21 238,59.18 238,58.67 239.27,57.4 239.78,57.4 241.3,55.88 v241.3,55.63
  Bottom 0.305: v77.72,8.38 76.45,9.65 67.82,9.65 65.28,12.19 64.01,12.19 63.25,12.95 58.17,12.95 51.82,19.3 45.47,19.3 44.45,20.32 42.42,20.32 37.08,25.65 32.77,25.65 30.99,27.43 28.96,27.43 20.32,36.07 18.03,36.07 B23.L2 | v139.45,39.37 139.7,39.37 147.07,32 157.23,32 165.1,24.13 v165.1,23.88 | v227.33,53.85 v231.14,53.85 | v241.3,55.63 245.36,55.63 B05.D2
P_DATA10  (via drill 0.61)
  Top 0.305: v56.64,72.9 18.03,34.29 18.03,30.73 B23.N2 | v66.04,72.9 74.93,72.9 93.47,91.44 95.76,91.44 134.37,130.05 144.78,130.05 v157.23,142.49 | v224.54,95 224.54,95.5 225.3,96.27 | 225.3,96.27 234.7,105.66 234.7,109.73 245.36,120.4 247.4,120.4 A05.E2 | v224.03,85.85 224.03,88.65 225.3,89.92 225.3,96.27
  Bottom 0.305: v66.04,72.9 v56.64,72.9 | v157.23,142.49 176.28,142.49 223.27,95.5 224.03,95.5 v224.54,95 | v224.03,85.85 241.55,68.33 241.55,64.52 248.92,57.15 248.92,53.09 B05.E2
P_DATA11  (via drill 0.61)
  Top 0.305: v244.09,112.01 244.6,112.52 244.6,113.28 245.36,114.05 247.14,114.05 248.41,115.32 248.67,115.32 A05.H2
  2 0.305: v111.51,7.37 112.01,7.37 144.53,39.88 145.8,39.88 147.07,41.15 151.64,41.15 155.96,45.47 157.73,45.47 159.77,47.5 164.85,47.5 169.16,51.82 169.16,52.83 171.2,54.86 171.2,58.93 178.82,66.55 180.34,66.55 181.61,67.82 181.61,68.58 190.75,77.72 190.75,78.49 194.56,82.3 209.55,82.3 v209.8,82.04 210.57,82.8 211.84,82.8 212.85,83.82 212.85,87.88 223.52,98.55 233.93,98.55 241.05,105.66 243.08,105.66 246.38,108.97 v246.89,108.97
  15 0.305: v209.8,82.04 213.87,77.98 215.39,77.98 245.62,47.75 247.4,47.75 248.67,46.48 B05.H2
  Bottom 0.305: v111.51,7.37 111.76,7.11 109.98,5.33 108.97,5.33 108.71,5.59 103.12,5.59 101.6,7.11 99.57,7.11 99.31,7.37 77.22,7.37 75.69,8.89 67.56,8.89 66.8,9.65 61.47,9.65 58.93,12.19 57.91,12.19 54.1,16 48.77,16 46.23,18.54 45.21,18.54 44.45,19.3 39.12,19.3 36.07,22.35 23.37,22.35 22.35,23.37 18.03,23.37 B23.R2 | v244.09,112.01 244.09,111.76 v246.89,108.97
P_DATAIN  (via drill 0.61)
  Top 0.305: v95.5,11.43 98.3,11.43 99.31,12.45 105.66,12.45 108.97,15.75 114.3,15.75 v135.64,37.08 | v172.47,18.03 174.75,18.03 v179.07,22.35 | v226.31,1.78 228.85,1.78 229.36,2.29 231.39,2.29 232.16,3.05 241.05,3.05 v258.57,20.57 | v268.99,44.45 268.73,44.45 265.94,41.66 265.94,39.37 263.65,37.08 263.65,35.81 261.87,34.04 B04.M2
  2 0.305: v258.57,20.57 256.03,23.11 257.81,24.89 257.81,25.91 259.84,27.94 259.84,29.21 260.1,29.46 260.1,31.5 B04.M2 | v237.49,76.71 250.7,89.92 251.46,89.92 260.6,99.06 260.6,99.57 261.37,100.33 261.37,102.62 A04.M2
  15 0.305: v237.49,76.71 237.24,76.45 235.71,77.98 235.71,78.99 237.24,80.52 239.01,78.74 241.55,78.74 243.08,77.22 243.08,75.69 251.46,67.31 252.98,67.31 253.49,66.8 253.49,63.75 267.46,49.78 267.46,48.77 269.75,46.48 269.75,45.21 v268.99,44.45
  Bottom 0.305: v95.5,11.43 83.57,23.37 81.53,23.37 B18.R2 | v135.64,37.08 144.53,45.97 v172.47,18.03 | v179.07,22.35 181.1,22.35 181.86,21.59 182.88,21.59 185.17,19.3 190.5,19.3 194.56,15.24 195.58,15.24 201.17,9.65 204.22,9.65 208.53,5.33 210.06,5.33 213.36,2.03 213.87,2.03 214.12,1.78 217.68,1.78 218.44,1.02 222.5,1.02 224.79,3.3 v226.31,1.78
P_EXTA0  (via drill 0.61)
  Top 0.305: B19.R2 67.82,23.11 66.55,21.84 66.55,20.32 66.29,20.07 66.29,19.56 61.47,14.73 69.6,6.6 75.95,6.6 76.45,7.11 78.49,7.11 78.74,7.37 102.87,7.37 103.89,8.38 106.93,8.38 111.25,12.7 113.28,12.7 113.54,12.95 116.59,12.95 118.62,14.99 120.65,14.99 137.67,32 154.69,32 169.93,47.24 v169.93,47.5 170.18,47.5 178.05,55.37 178.05,59.44 192.28,73.66 v194.82,73.66 | v226.82,70.87 229.62,70.87 234.44,75.69 242.57,75.69 245.62,78.74 245.62,80.26 A05.V2 | v217.68,77.47 216.66,77.47 v205.99,66.8
  2 0.305: v214.63,2.79 217.42,5.59 217.42,7.11 218.95,8.64 228.6,8.64 236.47,16.51 241.55,11.43 245.36,11.43 B05.V2
  Bottom 0.305: v214.63,2.79 214.38,2.79 169.93,47.24 v169.93,47.5 | v226.82,70.87 224.28,70.87 v217.68,77.47 | v205.99,66.8 204.98,66.8 199.14,72.64 198.12,72.64 197.61,73.15 195.33,73.15 v194.82,73.66
P_EXTA1  (via drill 0.61)
  Top 0.305: B19.N2 67.82,29.46 67.82,25.4 60.45,18.03 60.45,14.73 74.17,1.02 139.19,1.02 140.46,2.29 148.84,2.29 v149.1,2.54 155.7,9.14 155.7,18.03 158.24,20.57 158.24,21.59 158.75,22.1 v158.75,24.13 | v199.64,85.6 197.87,85.6 193.8,81.53 193.8,77.72 187.96,71.88 187.96,71.63 172.72,56.39 172.47,56.39 171.96,55.88 171.96,55.37 160.27,43.69 160.27,42.93 v150.37,33.02
  2 0.305: v149.1,2.54 156.97,2.54 157.73,3.3 160.02,3.3 162.31,1.02 199.64,1.02 200.91,2.29 201.42,2.29 202.18,3.05 203.2,3.05 203.45,3.3 205.49,3.3 205.74,3.56 212.85,3.56 218.69,9.4 228.35,9.4 239.01,20.07 241.55,20.07 244.6,17.02 245.36,17.78 B05.T2 | v220.47,104.65 220.47,104.14 215.14,98.81 215.14,97.54 216.15,96.52 216.15,93.47 211.84,89.15 205.74,89.15 202.69,86.11 202.18,86.11 201.93,85.85 199.9,85.85 v199.64,85.6
  15 0.305: v220.47,104.65 230.12,95 233.93,95 234.7,94.23 235.97,94.23 239.01,91.19 239.78,91.19 243.33,87.63 245.36,87.63 A05.T2 | v150.37,33.02 150.37,32.51 v158.75,24.13
P_EXTA2  (via drill 0.61)
  Top 0.305: v229.62,5.33 239.78,15.49 241.55,15.49 246.13,20.07 248.67,20.07 B05.S2 | v165.1,64.77 163.32,64.77 148.34,49.78 145.8,49.78 144.27,51.31 138.68,45.72 136.65,45.72 113.28,22.35 101.6,22.35 97.79,18.54 96.77,18.54 94.23,16 v89.41,16 | v226.82,111 226.82,109.47 220.98,103.63 219.96,103.63 214.88,98.55 v213.36,98.55
  2 0.305: v89.41,16 86.87,16 67.56,35.31 68.07,35.81 B19.L2 | v199.64,104.39 198.88,105.16 198.37,105.16 181.1,87.88 181.1,83.82 171.96,74.68 171.7,74.68 171.2,74.17 171.2,71.63 165.35,65.79 165.35,65.02 v165.1,64.77
  15 0.305: v229.62,5.33 227.08,2.79 221.49,8.38 218.95,8.38 196.09,31.24 196.09,32.26 192.53,35.81 192.53,37.34 v165.1,64.77 | v226.82,111 235.2,102.62 235.2,96.27 239.52,91.95 243.33,91.95 244.35,90.93 248.67,90.93 A05.S2
  Bottom 0.305: v213.36,98.55 211.33,98.55 208.53,101.35 202.69,101.35 v199.64,104.39
P_INIT  (via drill 0.61)
  Top 0.305: v280.42,68.58 284.23,68.58 296.16,80.52 A01.V2 | B04.V2 258.32,10.41 258.32,8.89 254.51,5.08 254.51,4.06 257.56,1.02 286.51,1.02 296.16,10.67 B01.V2 | v273.56,73.66 253.49,53.59 253.49,52.58 v251.21,50.29 | v247.14,41.66 247.14,41.15 245.87,39.88 245.87,38.35 241.55,34.04 241.55,32 B06.N1
  2 0.305: v251.21,50.29 251.21,50.04 247.9,46.74 247.9,42.42 v247.14,41.66
  15 0.305: 271.78,71.88 274.32,69.34 279.65,69.34 v280.42,68.58 | 271.78,71.88 263.4,80.26 260.86,80.26 260.6,80.52 259.33,80.52 A04.V2 | v252.73,19.3 242.32,29.72 240.28,29.72 B06.N1 | v273.56,73.66 271.78,71.88
  Bottom 0.305: v252.73,19.3 253.24,19.3 255.52,17.02 256.29,17.02 256.79,16.51 256.79,14.99 257.05,14.73 257.05,12.95 258.32,11.68 B04.V2
P_IOP1  (via drill 0.61)
  Top 0.305: v275.59,32 276.61,32 287.27,42.67 288.04,42.67 289.56,44.2 v292.61,44.2 293.12,44.7 294.39,44.7 301.75,52.07 301.75,56.13 304.04,58.42 v304.29,58.42 | v288.8,93.47 289.05,93.73 289.05,94.23 291.59,96.77 291.59,97.79 293.37,99.57 293.37,100.84 299.47,106.93 299.47,108.97 A01.K2
  2 0.305: v288.8,93.47 288.8,92.2 293.12,87.88 291.34,86.11 291.34,83.82 289.05,81.53 289.05,78.74 v286.51,76.2
  15 0.305: v260.1,48.26 260.1,46.99 260.35,46.74 260.35,45.72 274.07,32 v275.59,32
  Bottom 0.305: v260.1,48.26 260.1,49.78 245.11,64.77 243.59,64.77 B06.A1 | v292.61,44.2 293.62,44.2 296.42,41.4 298.2,41.4 299.47,40.13 B01.K2 | v304.29,58.42 v286.51,76.2
P_IOP2  (via drill 0.61)
  Top 0.305: v298.2,92.71 298.2,91.95 293.37,87.12 292.86,87.12 v284.73,78.99
  2 0.305: v298.2,92.71 298.45,92.96 298.45,94.74 298.7,95 298.7,97.54 299.47,98.3 299.47,102.62 A01.M2 | v284.73,78.99 284.73,74.42 282.45,72.14 281.43,72.14 277.62,68.33 277.62,64.52 v273.3,60.2
  Bottom 0.305: 298.96,32.26 297.94,31.24 298.2,30.99 298.2,25.4 298.96,24.64 298.96,23.62 304.55,18.03 304.55,16.51 296.67,8.64 292.86,12.45 286,12.45 246.63,51.82 245.36,51.82 243.33,53.85 241.55,53.85 240.28,55.12 B06.D1 | 298.96,32.26 B01.M2 | v273.3,60.2 273.3,57.91 298.96,32.26
P_IOP4  (via drill 0.61)
  Top 0.305: v252.98,59.44 243.33,49.78 240.28,49.78 B06.F1 | v285.75,26.16 291.34,20.57 295.91,25.15 298.2,25.15 B01.P2
  2 0.305: v292.86,105.92 292.86,105.41 285.24,97.79 285.24,96.77 282.7,94.23 282.7,88.9 269.24,75.44 269.24,74.93 261.62,67.31 261.62,66.8 260.6,65.79 260.6,61.72 259.33,60.45 254,60.45 v252.98,59.44
  Bottom 0.305: v252.98,59.44 252.98,57.91 253.49,57.4 254.51,57.4 v285.75,26.16 | v292.86,105.92 299.72,99.06 299.72,97.54 A01.P2
P_IRQ  (via drill 0.61)
  Top 0.305: v262.38,9.4 262.64,9.65 265.68,9.65 279.15,23.11 279.15,23.37 279.65,23.88 278.38,25.15 277.37,25.15 276.1,26.42 276.1,27.43 274.57,28.96 274.57,32.77 B03.M2 | v250.7,17.27 250.19,17.27 237.49,4.57 230.38,4.57 230.12,4.32 227.33,4.32 v224.79,1.78 | v175.01,14.22 170.43,9.65 169.16,9.65 166.88,7.37 159.51,7.37 v153.67,1.52 | v267.46,106.93 268.48,106.93 v275.08,113.54
  2 0.305: v275.08,113.54 272.29,116.33 272.54,116.59 272.54,118.11 276.1,121.67 276.1,123.95 267.72,132.33 269.75,134.37 v269.75,139.19 | v257.05,143.26 245.11,143.26 244.09,142.24 241.81,142.24 240.54,143.51 223.77,143.51 223.52,143.26 223.52,142.75 223.01,142.24 221.49,142.24 204.22,124.97 204.22,123.7 194.31,113.79 193.04,113.79 186.18,106.93 185.17,106.93 176.78,98.55 171.45,98.55 164.08,91.19 163.32,91.19 v159.77,87.63 | v164.85,79.25 145.54,59.94 145.29,59.94 131.32,45.97 131.32,45.72 130.81,45.21 129.79,45.21 116.59,32 105.92,32 v105.41,31.5
  15 0.305: v224.79,1.78 223.77,1.78 221.74,3.81 220.73,3.81 219.71,4.83 203.45,4.83 200.91,7.37 194.82,7.37 194.31,7.87 182.12,7.87 180.85,9.14 180.09,9.14 v175.01,14.22
  Bottom 0.305: v262.38,9.4 258.57,9.4 v250.7,17.27 | v153.67,1.52 142.24,1.52 141.48,2.29 128.78,2.29 128.02,3.05 125.22,3.05 101.09,27.18 | 101.09,27.18 82.8,45.47 82.8,46.99 81.28,48.51 B18.F2 | v267.46,106.93 274.32,100.08 275.34,101.09 275.34,102.11 275.08,102.36 275.08,102.62 A03.M2 | v269.75,139.19 262.64,139.19 260.86,140.97 259.33,140.97 v257.05,143.26 | v159.77,87.63 166.12,81.28 166.12,80.01 165.1,78.99 v164.85,79.25 | 101.09,27.18 v105.41,31.5
P_LINE  (via drill 0.61)
  Top 0.305: v115.06,5.33 141.99,5.33 155.19,18.54 155.19,20.07 155.45,20.32 155.45,24.13 159.77,28.45 171.45,28.45 172.21,29.21 172.97,29.21 187.96,44.2 192.53,44.2 192.79,43.94 v192.53,43.69 | v259.59,4.06 260.35,4.06 262.38,6.1 264.41,6.1 268.73,10.41 270.51,10.41 270.76,10.67 B03.V2 | v261.11,71.88 262.64,71.88 271.02,80.26 A03.V2 | v200.66,44.7 v216.15,60.2
  2 0.305: v239.27,90.17 239.27,89.92 237.49,88.14 237.49,87.12 216.15,65.79 v216.15,60.2
  15 0.305: v192.53,43.69 198.63,37.59 198.63,35.05 202.95,30.73 202.95,26.92 207.52,22.35 211.33,22.35 216.41,17.27 218.95,17.27 226.57,9.65 235.71,9.65 235.97,9.4 249.17,9.4 255.02,3.56 256.54,3.56 258.06,2.03 259.08,2.03 260.35,3.3 v259.59,4.06
  Bottom 0.305: v115.06,5.33 88.39,32 83.57,32 81.28,34.29 81.28,35.81 B18.L2 | v261.11,71.88 258.06,71.88 243.59,86.36 243.08,86.36 v239.27,90.17 | v200.66,44.7 200.66,45.72 195.83,50.55 194.31,50.55 189.99,46.23 v192.53,43.69
P_MB00  (via drill 0.61)
  Top 0.305: v281.43,69.6 282.45,69.6 295.66,82.8 295.66,83.31 295.91,83.57 295.91,84.33 301.5,89.92 301.5,94.23 305.82,98.55 305.82,99.57 303.53,101.85 303.53,104.65 304.55,105.66 v304.55,113.79 | A06.B1 240.28,132.33 244.6,132.33 245.36,133.1 251.71,133.1 255.02,136.4 264.41,136.4 264.67,136.65 265.94,136.65 266.7,137.41 280.42,137.41 280.67,137.67 282.7,137.67 289.05,131.32 289.81,132.08 A02.B1
  2 0.305: v223.77,120.65 224.79,120.65 228.85,124.71 229.36,124.71 229.62,124.97 230.89,124.97 235.97,130.05 237.74,130.05 239.01,131.32 A06.B1
  15 0.305: v223.77,120.65 223.77,116.59 A07.H2
  Bottom 0.305: v281.43,69.6 286,65.02 286,64.52 288.29,62.23 289.81,62.23 B02.B1 | v304.55,113.79 304.55,114.81 297.94,121.41 297.94,122.43 292.35,128.02 292.35,129.54 290.83,131.06 A02.B1
P_MB01  (via drill 0.61)
  Top 0.305: v225.55,105.41 225.3,105.16 225.3,102.62 223.27,100.58 221.23,100.58 A07.N2 | v220.47,114.3 220.47,114.55 226.31,120.4 232.66,120.4 235.97,123.7 237.74,123.7 239.01,124.97 A06.D1 | v283.72,51.31 287.53,55.12 289.81,55.12 B02.D1 | v278.13,133.6 271.53,133.6 268.48,136.65 266.95,136.65 266.19,135.89 264.92,135.89 256.29,127.25 v246.13,127.25
  Bottom 0.305: v225.55,105.41 225.55,109.73 221.23,114.05 220.73,114.05 v220.47,114.3 | v283.72,51.31 283.72,52.83 266.19,70.36 264.16,70.36 261.62,72.9 258.06,72.9 239.78,91.19 238.76,91.19 238,90.42 238,89.66 235.46,87.12 224.28,98.3 222.5,98.3 221.23,99.57 A07.N2 | v278.13,133.6 286,125.73 289.81,125.73 A02.D1 | v246.13,127.25 241.55,127.25 A06.D1
P_MB02  (via drill 0.61)
  Top 0.305: v286.77,113.79 287.27,113.79 291.85,118.36 291.85,120.4 A02.E1 | v261.62,107.95 261.62,107.19 254.51,100.08 254.25,100.08 253.75,99.57 253.75,98.04 v252.22,96.52 | v301.5,67.06 301.5,64.52 295.91,58.93 295.91,57.91 294.13,56.13 294.13,53.09 B02.E1
  2 0.305: v237.49,70.87 238.25,70.1 248.16,80.01 248.16,80.52 v257.81,90.17 260.35,92.71 260.86,92.71 264.92,96.77 265.18,96.77 | 265.18,96.77 265.43,96.77 265.68,97.03 266.45,97.03 274.07,104.65 278.13,104.65 285.5,112.01 285.5,112.52 v286.77,113.79 | 265.18,96.77 v265.18,97.03
  15 0.305: v252.22,96.52 252.22,95.76 v257.81,90.17
  Bottom 0.305: v237.49,70.87 236.47,71.88 234.19,71.88 224.28,81.79 224.28,83.57 A07.U2 | v261.62,107.95 253.75,115.82 253.75,119.63 252.48,120.9 248.67,120.9 247.65,121.92 243.59,121.92 A06.E1 | v301.5,67.06 300.99,67.06 300.74,67.31 300.23,67.31 297.69,69.85 294.39,69.85 287.02,77.22 284.99,77.22 v265.18,97.03
P_MB03  (via drill 0.61)
  Top 0.305: v209.8,98.3 210.57,98.3 229.62,117.35 230.12,117.35 v231.39,118.62 | v288.04,41.4 289.05,42.42 289.81,42.42 B02.J1 | v265.68,69.34 266.19,69.34 271.27,74.42 v271.27,75.95 | v278.38,102.62 280.16,104.39 280.42,104.39 281.94,105.92 281.94,106.17 288.04,112.27 289.81,112.27 A02.J1 | v268.73,111.25 266.95,111.25 v254.76,99.06
  15 0.305: v209.8,98.3 208.53,99.57 A08.N2
  Bottom 0.305: v231.39,118.62 231.9,118.62 235.97,114.55 237.49,114.55 239.01,113.03 A06.J1 240.28,112.27 241.55,111 243.33,111 255.02,99.31 | v288.04,41.4 288.04,41.91 265.68,64.26 v265.68,69.34 | v271.27,75.95 271.27,79.25 270,80.52 270,84.33 255.02,99.31 | v278.38,102.62 275.59,105.41 274.57,105.41 v268.73,111.25 | 255.02,99.31 v254.76,99.06
P_MB03\  (via drill 0.61)
  Top 0.305: v225.3,127.25 214.38,116.33 211.84,116.33 A08.H2
  2 0.305: v305.82,62.48 294.13,50.8 294.13,46.74 B02.H1 | v297.18,74.93 297.43,74.93 300.99,78.49 300.99,81.03 297.94,84.07 299.21,85.34 299.21,87.63 301.5,89.92 301.5,100.58 v302.51,101.6 | v265.94,130.05 261.37,130.05 255.78,124.46 254.76,124.46 246.63,116.33 243.59,116.33 A06.H1
  15 0.305: v225.3,127.25 233.43,127.25 241.05,119.63 241.05,118.11 242.57,116.59 A06.H1 | v265.94,130.05 277.62,130.05 290.07,117.6 291.85,117.6 293.12,116.33 A02.H1
  Bottom 0.305: v305.82,62.48 305.82,63.75 305.05,64.52 305.05,67.06 v297.18,74.93 | v302.51,101.6 302.51,105.16 295.4,112.27 295.4,114.05 294.13,115.32 A02.H1
P_MB04  (via drill 0.61)
  Top 0.305: v304.8,40.89 297.69,33.78 294.39,33.78 B02.M1 | v277.88,79.25 278.13,79.25 279.15,80.26 279.15,84.58 284.73,90.17 284.73,91.95 291.85,99.06 291.85,100.33 294.13,102.62 A02.M1 | v249.17,106.68 246.13,103.63 243.59,103.63 A06.M1 241.3,101.6 v241.05,101.6 | v215.39,126.75 213.61,126.75 211.33,124.46 210.31,124.46 202.18,116.33 199.14,116.33 A09.H2
  Bottom 0.305: v304.8,40.89 304.8,44.45 303.78,45.47 303.78,47.5 306.58,50.29 292.35,64.52 292.35,65.53 289.81,68.07 289.05,68.07 v277.88,79.25 277.62,79.25 273.81,83.06 272.29,83.06 249.17,106.17 v249.17,106.68 | v215.39,126.75 216.15,126.75 223.27,119.63 223.27,119.13 224.79,117.6 226.31,117.6 229.11,114.81 229.11,114.05 233.17,109.98 233.17,109.47 v241.05,101.6
P_MB04\  (via drill 0.61)
  Top 0.305: v245.36,115.06 240.28,109.98 240.28,106.93 A06.L1
  2 0.305: A08.U2 210.57,84.58 209.04,86.11 209.3,86.36 209.3,86.87 209.8,87.38 211.33,87.38 223.27,99.31 224.28,99.31 226.31,101.35 232.66,101.35 235.97,104.65 237.74,104.65 239.01,105.92 A06.L1 | v288.29,57.4 288.29,57.66 288.8,58.17 288.8,63.5 290.58,65.28 290.58,65.79 v302.77,77.98 | v245.36,115.06 246.38,115.06 255.02,123.7 v270.26,123.7
  15 0.305: v290.07,51.56 296.42,45.21 291.08,39.88 291.08,37.08 B02.L1 | v302.77,77.98 306.58,81.79 305.05,83.31 305.05,88.14 298.7,94.49 298.7,100.08 294.13,104.65 292.35,104.65 291.08,105.92 A02.L1
  Bottom 0.305: v290.07,51.56 290.07,54.1 289.05,55.12 289.05,56.64 v288.29,57.4 | v270.26,123.7 275.08,123.7 288.8,109.98 288.8,108.2 290.07,106.93 A02.L1
P_MB05  (via drill 0.61)
  Top 0.305: v214.63,71.12 215.14,71.12 232.66,88.65 238.25,88.65 | 238.25,88.65 241.05,88.65 A06.S1 | v260.1,76.45 v251.97,68.33 | v287.53,86.87 290.58,89.92 293.12,89.92 A02.S1 | v257.05,106.17 255.02,106.17 254.51,105.66 253.75,105.66 249.94,101.85 246.89,101.85 246.38,101.35 245.36,101.35 238.25,94.23 238.25,88.65
  15 0.305: v260.1,76.45 259.84,76.45 256.54,79.76 255.52,79.76 246.63,88.65 245.11,88.65 243.59,90.17 A06.S1
  Bottom 0.305: v214.63,71.12 201.93,83.82 199.14,83.82 A09.U2 | v251.97,68.33 254.25,66.04 254.25,64.52 256.03,62.74 256.03,61.47 293.37,24.13 293.37,21.34 B02.S1 | v287.53,86.87 286.51,86.87 283.46,89.92 283.21,89.92 282.45,90.68 282.45,90.93 268.73,104.65 263.91,104.65 261.62,106.93 261.11,106.93 259.08,108.97 258.06,108.97 256.03,111 254.76,111 253.49,109.73 v257.05,106.17
P_MB05\  (via drill 0.61)
  Top 0.305: v231.9,104.39 230.63,105.66 212.85,87.88 212.85,87.38 v211.84,86.36 | v302.77,84.33 302.77,83.57 298.96,79.76 297.43,79.76 297.18,79.5 296.42,79.5 292.1,75.18 292.1,74.68 284.48,67.06 284.48,66.55 281.43,63.5 v281.18,63.5
  2 0.305: v241.05,95.25 242.06,96.27 242.32,96.27 A06.P1
  15 0.305: B02.P1 294.39,27.43 297.43,27.43 306.32,36.32 306.32,36.83 290.58,52.58 289.05,52.58 v286,55.63 284.99,56.64 284.99,59.18 281.18,62.99 v281.18,63.5
  Bottom 0.305: v231.9,104.39 v241.05,95.25 258.83,77.47 260.6,77.47 260.86,77.22 262.89,77.22 265.43,74.68 265.94,74.68 270.76,69.85 271.78,69.85 282.96,58.67 282.96,58.17 284.23,56.9 284.73,56.9 v286,55.63 | v211.84,86.36 210.82,87.38 209.8,87.38 198.88,98.3 197.1,98.3 195.83,99.57 A09.N2 | v302.77,84.33 302.77,84.58 294.39,92.96 294.39,93.47 294.13,93.73 294.13,96.27 A02.P1
P_MB06  (via drill 0.61)
  Top 0.305: v234.19,90.93 234.7,90.93 235.46,91.69 235.46,92.46 245.11,102.11 246.13,102.11 251.71,107.7 254,107.7 | 254,107.7 256.79,107.7 258.06,108.97 259.33,108.97 261.37,111 265.43,111 268.48,114.05 270.76,114.05 277.11,120.4 285.5,120.4 A02.E2 | v261.37,81.28 261.37,81.53 v270,90.17 | 254,107.7 v254,106.68 | v239.52,123.7 238.51,122.68 237.24,122.68 A06.E2
  2 0.305: v212.34,70.36 214.12,72.14 215.39,72.14 v234.19,90.93
  Bottom 0.305: v212.34,70.36 203.2,79.5 201.17,79.5 190.25,90.42 190.25,94.23 184.91,99.57 183.13,99.57 A10.N2 | v261.37,81.28 282.96,59.69 284.48,59.69 287.02,57.15 287.02,53.09 B02.E2 | v270,90.17 270,90.68 v254,106.68 251.46,109.22 251.46,110.49 245.11,116.84 245.11,118.11 v239.52,123.7
P_MB06\  (via drill 0.61)
  Top 0.305: v214.12,143.26 214.12,141.73 201.17,128.78 201.17,128.27 189.23,116.33 186.44,116.33 A10.H2 | v276.1,51.31 278.13,53.34 278.64,53.34 280.42,55.12 283.46,55.12 B02.D2 | v273.81,76.45 273.81,80.26 279.91,86.36 279.91,87.12 v283.72,90.93 | v276.86,98.04 274.57,100.33 275.34,101.09 275.34,101.85 279.15,105.66 279.15,106.17 280.42,107.44 280.92,107.44 285.5,112.01 285.5,116.08 286.77,117.35 287.27,117.35 v287.53,117.6
  2 0.305: v276.1,51.31 276.1,53.09 273.56,55.63 272.03,54.1 270.76,54.1 268.22,56.64 276.1,64.52 276.1,68.33 277.88,70.1 277.88,72.39 v273.81,76.45 | A06.D2 233.93,125.98 235.97,125.98 241.05,131.06 241.05,131.32 241.3,131.57 241.81,131.57 242.06,131.83 244.09,131.83 248.67,136.4 251.71,136.4 254,138.68 255.02,138.68 257.05,140.72 259.59,140.72 259.84,140.97 272.29,140.97 285.5,127.76 283.72,125.98 A02.D2
  Bottom 0.305: v214.12,143.26 214.12,141.48 219.2,136.4 220.47,136.4 229.62,127.25 231.14,127.25 232.66,125.73 A06.D2 | v283.72,90.93 283.72,91.19 v276.86,98.04 | v287.53,117.6 287.53,120.14 286,121.67 286,123.19 284.48,124.71 A02.D2
P_MB07  (via drill 0.61)
  Top 0.305: v254,112.27 256.29,112.27 258.06,114.05 264.41,114.05 267.72,117.35 v271.27,117.35 | v267.97,60.45 274.07,66.55 275.84,66.55 280.42,71.12 280.42,71.63 v281.94,73.15
  2 0.305: v254,112.27 252.48,110.74 250.95,112.27 248.67,112.27 242.82,106.43 240.03,109.22 237.24,109.22 A06.K2 | v215.14,142.24 211.07,138.18 203.2,138.18 201.42,136.4 197.87,136.4 182.63,121.16 181.61,121.16 176.78,116.33 173.74,116.33 A11.H2 | v281.94,73.15 281.94,79.5 282.7,80.26 282.7,83.82 286.77,87.88 286.77,89.15 284.99,90.93 287.78,93.73 287.78,93.98 294.13,100.33 v294.39,100.33
  15 0.305: v215.14,142.24 218.95,142.24 219.2,141.99 220.22,141.99 220.73,141.48 222.76,141.48 224.54,139.7 229.11,139.7 229.36,139.45 241.81,139.45 254.76,126.49 255.78,126.49 258.32,123.95 262.13,123.95 266.7,119.38 269.24,119.38 v271.27,117.35
  Bottom 0.305: v271.27,117.35 276.61,117.35 277.11,116.84 278.13,116.84 283.72,111.25 285.5,111.25 286.77,109.98 A02.K2 287.02,108.97 289.05,106.93 289.05,105.92 294.39,100.58 v294.39,100.33 | v267.97,60.45 268.22,60.2 268.73,60.2 287.02,41.91 287.02,40.39 B02.K2
P_MB07\  (via drill 0.61)
  Top 0.305: v265.94,134.62 264.92,134.62 254,123.7 248.67,123.7 246.13,121.16 245.11,121.16 240.28,116.33 237.24,116.33 A06.H2 | v292.1,45.72 288.04,45.72 B02.H2 | v265.18,72.9 264.67,72.9 259.33,67.56 256.79,67.56 v256.03,66.8 | v204.47,107.7 204.47,107.19 v184.91,87.63
  2 0.305: v223.27,126.75 223.27,125.98 204.72,107.44 v204.47,107.7
  15 0.305: v223.27,126.75 229.62,120.4 233.93,120.4 236.22,118.11 236.22,116.59 A06.H2
  Bottom 0.305: v265.94,134.62 268.22,136.91 285.5,119.63 285.5,118.11 287.02,116.59 A02.H2 | v292.1,45.72 290.58,45.72 290.07,46.23 290.07,47.75 285.75,52.07 285.75,52.32 285.24,52.83 284.73,52.83 273.3,64.26 273.3,64.77 v265.18,72.9 | v256.03,66.8 255.02,66.8 252.48,69.34 250.95,69.34 242.57,77.72 241.55,77.72 241.3,77.98 240.28,77.98 232.66,85.6 232.16,85.6 218.19,99.57 216.66,99.57 214.88,101.35 210.82,101.35 v204.47,107.7 | v184.91,87.63 184.91,85.34 185.42,84.84 A10.U2
P_MB08  (via drill 0.61)
  Top 0.305: v191.52,114.3 190.25,113.03 190.25,112.01 188.98,110.74 188.98,109.73 174.5,95.25 174.5,89.92 173.48,88.9 173.48,84.84 A11.U2 | v190.75,119.38 191.26,119.38 199.9,128.02 199.9,128.52 v200.15,128.78 | v262.13,117.6 254,117.6 245.87,109.47 245.87,108.2 238.25,100.58 238.25,98.81 236.98,97.54 A06.P2
  2 0.305: v305.31,68.33 293.88,56.9 292.35,56.9 291.85,56.39 291.85,54.86 284.48,47.5 285.5,46.48 285.5,42.16 284.99,41.66 284.99,40.64 284.73,40.39 288.8,36.32 288.8,32.77 287.78,31.75 287.78,27.69 B02.P2 | v292.1,82.3 292.1,85.85 293.88,87.63 293.88,88.65 295.15,89.92 295.15,99.57 295.4,99.82 295.4,100.84 294.39,101.85 291.08,98.55 289.31,98.55 288.04,97.28 A02.P2
  15 0.305: v268.99,113.03 266.7,113.03 v262.13,117.6
  Bottom 0.305: v305.31,68.33 305.31,69.09 v292.1,82.3 | v191.52,114.3 191.52,114.55 190.75,115.32 v190.75,119.38 | v200.15,128.78 198.88,130.05 197.61,130.05 196.34,128.78 216.92,108.2 220.73,108.2 222,106.93 222,103.12 223.27,101.85 233.43,101.85 234.7,100.58 234.7,99.06 236.22,97.54 A06.P2 | v268.99,113.03 277.37,104.65 281.43,104.65 287.02,99.06 287.02,97.54 A02.P2
P_MB08\  (via drill 0.61)
  Top 0.305: v177.29,104.9 172.97,100.58 170.43,100.58 A11.N2 | v276.35,95.25 283.72,102.62 286.77,102.62 A02.M2 | v263.65,99.06 262.13,99.06 254.25,91.19 254.25,90.17 v254,89.92
  2 0.305: v194.82,91.44 195.07,91.44 206.25,102.62 206.25,103.38 207.01,104.14 207.77,104.14 218.95,115.32 218.95,115.82 v219.2,116.08 | v277.11,27.43 282.45,32.77 286.77,32.77 B02.M2 | v262.13,41.66 260.86,42.93 259.33,41.4 257.05,41.4 256.03,42.42 255.02,42.42 254.51,41.91 254.51,41.4 v254.25,41.15
  15 0.305: v254.25,41.15 251.21,41.15 239.78,52.58 239.01,52.58 v224.54,67.06
  Bottom 0.305: v177.29,104.9 181.36,104.9 v194.82,91.44 195.07,91.69 214.63,72.14 215.14,72.14 218.69,68.58 221.23,68.58 222.76,67.06 v224.54,67.06 | v219.2,116.08 220.22,116.08 226.31,109.98 227.84,109.98 232.92,104.9 234.7,104.9 235.97,103.63 A06.M2 236.98,102.62 238.25,101.35 238.25,99.57 249.43,88.39 250.95,89.92 v254,89.92 | v277.11,27.43 276.35,27.43 v262.13,41.66 | v276.35,95.25 274.32,95.25 273.3,96.27 270.76,96.27 268.73,98.3 264.41,98.3 v263.65,99.06
P_MB09  (via drill 0.61)
  Top 0.305: v184.15,140.21 180.59,140.21 165.86,125.48 165.86,123.44 162.05,119.63 162.05,117.86 160.78,116.59 A12.H2 | v290.83,33.02 283.97,26.16 287.02,23.11 287.02,21.34 B02.S2
  2 0.305: v290.83,33.02 290.83,34.8 291.85,35.81 291.85,39.37 287.78,43.43 v291.08,46.74 | v275.59,89.15 275.34,89.15 v262.38,76.2
  15 0.305: v291.08,46.74 285.75,52.07 285.75,52.32 285.24,52.83 283.72,52.83 266.19,70.36 264.16,70.36 262.38,72.14 | 262.38,72.14 261.62,72.9 256.03,72.9 240.28,88.65 238.76,88.65 237.24,90.17 A06.S2 | v275.59,89.15 276.1,88.65 278.38,88.65 279.91,87.12 282.7,89.92 286.77,89.92 A02.S2 | 262.38,72.14 v262.38,76.2
  Bottom 0.305: v184.15,140.21 185.67,138.68 185.67,138.43 219.46,104.65 219.46,104.14 233.68,89.92 235.97,89.92 A06.S2
P_MB10  (via drill 0.61)
  Top 0.305: v198.12,66.8 198.88,66.8 203.45,71.37 204.72,71.37 v211.58,78.23 | v218.69,73.15 221.23,73.15 228.35,80.26 228.35,81.03 230.12,82.8 231.9,82.8 233.17,84.07 233.17,86.61 A06.T2
  2 0.305: v266.45,35.56 266.45,40.13 265.43,41.15 266.45,42.16 266.45,48.51 269.75,51.82 269.75,54.1 261.37,62.48 263.4,64.52 263.4,65.02 263.91,65.53 | 263.91,65.53 272.8,74.42 272.8,77.98 280.42,85.6 282.19,85.6 283.46,86.87 A02.T2 | v262.64,66.8 263.91,65.53
  15 0.305: v161.54,101.6 160.53,100.58 157.73,100.58 A12.N2
  Bottom 0.305: v266.45,35.56 266.95,35.05 266.95,32.77 281.94,17.78 283.46,17.78 B02.T2 | v161.54,101.6 163.83,101.6 183.9,81.53 183.9,81.03 v198.12,66.8 | v211.58,78.23 213.61,78.23 v218.69,73.15 | v262.64,66.8 262.13,66.8 243.33,85.6 235.2,85.6 233.93,86.87 A06.T2
P_MB11  (via drill 0.61)
  Top 0.305: v274.32,8.64 275.34,9.65 278.38,9.65 279.15,10.41 282.96,10.41 283.21,10.67 283.46,10.67 B02.V2 | v217.42,60.45 217.42,61.21 219.46,63.25 219.46,68.07 232.66,81.28 A06.V2 235.2,82.8 237.24,82.8 238,83.57 v241.3,83.57 | v264.67,68.33 266.19,68.33 271.78,73.91 272.29,73.91 273.81,75.44 274.32,75.44 277.11,78.23 278.38,78.23 280.67,80.52 283.46,80.52 A02.V2 | v171.45,96.52 169.93,95 169.16,95 168.66,94.49 167.64,94.49 160.78,87.63 160.78,84.84 A12.U2
  15 0.305: v264.67,68.33 264.16,68.33 263.14,69.34 259.59,69.34 259.33,69.6 258.32,69.6 251.71,76.2 251.21,76.2 250.44,76.96 247.9,76.96 v241.3,83.57 | v171.45,96.52 171.45,96.27 181.86,85.85 188.21,85.85 206.25,67.82 206.5,67.82 210.57,63.75 214.38,63.75 217.42,60.71 v217.42,60.45
  Bottom 0.305: v274.32,8.64 272.03,8.64 259.08,21.59 257.56,21.59 245.62,33.53 245.62,34.29 241.81,38.1 241.81,38.35 241.3,38.86 239.27,38.86 217.68,60.45 v217.42,60.45
P_MBINCR  (via drill 0.61)
  2 0.305: v221.23,2.79 222,3.56 224.03,3.56 226.57,6.1 231.65,1.02 233.17,1.02 238.25,6.1 243.08,6.1 245.36,8.38 246.38,8.38 255.02,17.02 258.06,17.02 B04.T2 | v86.11,54.36 80.77,59.69 75.18,54.1 70.1,54.1 68.83,55.37 B19.D2 | v254,96.52 250.44,100.08 247.9,97.54 247.9,93.47 225.81,71.37 225.81,65.02 218.19,57.4 214.38,57.4 206.76,65.02 202.18,60.45 195.83,60.45 192.79,57.4 187.45,57.4 184.66,54.61 183.64,54.61 183.13,54.1 178.05,54.1 170.43,46.48 169.16,46.48 157.73,35.05 145.54,35.05 v143.51,33.02
  15 0.305: v221.23,2.79 216.15,2.79 215.14,3.81 196.34,3.81 193.8,6.35 179.58,6.35 178.31,7.62 176.02,7.62 173.74,9.91 172.97,9.91 170.43,12.45 166.37,12.45 162.56,16.26 160.27,16.26 v143.51,33.02 v130.3,46.23 | v254,96.52 258.83,91.69 258.83,87.88 A04.T2
  Bottom 0.305: v130.3,46.23 125.98,50.55 89.92,50.55 v86.11,54.36
P_RUN  (via drill 0.61)
  Top 0.305: v196.85,16.76 206.76,26.67 207.77,26.67 214.12,33.02 | 214.12,33.02 216.66,35.56 217.68,35.56 219.96,37.85 222,37.85 B07.K2 | 214.12,33.02 v213.87,33.27 | v265.43,82.8 266.95,84.33 266.95,84.84 272.03,89.92 274.07,89.92 A03.S2 | v270.26,74.93 269.75,74.93 263.65,68.83 263.65,64.77 256.29,57.4 251.97,57.4 243.59,49.02 241.55,49.02 v236.22,43.69
  2 0.305: v236.22,43.69 233.43,46.48 232.66,46.48 227.58,41.4 225.81,41.4 224.54,40.13 B07.K2
  15 0.305: v196.85,16.76 196.09,16 194.82,16 191.52,19.3 159.77,19.3 142.75,36.32 142.75,40.13 137.16,45.72 135.64,45.72 B14.H2
  Bottom 0.305: v213.87,33.27 220.98,26.16 222.5,26.16 223.52,25.15 227.58,25.15 242.32,10.41 243.08,10.41 246.63,6.86 247.14,6.86 252.98,1.02 276.1,1.02 285.5,10.41 285.5,11.68 276.86,20.32 275.34,20.32 B03.S2 | v265.43,82.8 265.43,82.55 266.45,81.53 266.45,78.74 v270.26,74.93
P_SKIP  (via drill 0.61)
  2 0.305: v244.09,78.74 245.87,78.74 247.4,80.26 247.4,84.84 261.37,98.81 261.37,99.31 270.51,108.46 273.56,108.46 A03.K2 | v160.78,119.89 160.27,120.4 156.46,120.4 119.13,83.06 118.11,83.06 102.36,67.31 99.57,67.31 98.3,66.04 98.3,64.52 90.17,56.39 89.41,56.39 88.65,55.63 88.65,54.86 86.36,52.58 83.82,55.12 81.53,55.12 B18.D2
  15 0.305: B03.K2 274.32,40.39 274.32,44.45 254.25,64.52 254.25,67.56 252.48,69.34 251.97,69.34 246.63,74.68 246.63,76.2 v244.09,78.74 243.33,79.5 239.27,79.5 233.17,85.6 v226.82,85.6 | v160.78,119.89 163.07,117.6 182.12,117.6 207.52,92.2 213.87,92.2 216.92,89.15 v218.44,89.15
  Bottom 0.305: v218.44,89.15 223.27,89.15 v226.82,85.6
P_TS1  (via drill 0.61)
  Top 0.305: B06.L1 239.78,37.08 239.78,38.61 248.67,47.5 254,47.5 257.81,51.31 258.83,51.31 261.37,53.85 265.43,53.85 276.1,64.52 276.1,65.79 280.92,70.61 282.45,70.61 294.89,83.06 294.89,83.57 295.15,83.82 295.15,85.34 296.42,86.61 A01.T2 | v274.32,4.83 275.08,5.59 283.97,5.59 288.04,9.65 291.08,9.65 296.42,14.99 296.42,16.76 B01.T2
  15 0.305: v274.32,4.83 272.29,4.83 270.26,6.86 266.45,6.86 262.89,10.41 261.37,10.41 259.33,12.45 255.52,12.45 254.25,13.72 254.25,19.3 243.08,30.48 243.08,31.24 241.55,32.77 241.55,34.29 240.03,35.81 B06.L1
P_TS3  (via drill 0.61)
  Top 0.305: v274.32,6.35 283.72,6.35 296.16,18.8 298.2,18.8 B01.S2
  2 0.305: v277.37,44.7 276.35,45.72 276.35,49.78 278.89,52.32 278.89,53.34 279.65,54.1 279.65,65.79 297.18,83.31 297.18,84.33 298.45,85.6 298.45,87.88 299.47,88.9 299.47,89.92 A01.S2
  15 0.305: v274.32,6.35 253.49,27.18 251.97,27.18 241.81,37.34 241.81,38.35 240.03,40.13 240.03,42.16 B06.J1
  Bottom 0.305: v277.37,44.7 277.88,44.7 289.81,32.77 289.81,32.51 290.83,31.5 291.08,31.5 298.2,24.38 298.2,22.86 299.72,21.34 B01.S2
P_TT_INST  (via drill 0.61)
  Top 0.305: v153.16,41.15 149.86,37.85 143.76,37.85 141.48,35.56 140.46,35.56 138.43,33.53 137.16,33.53 134.37,30.73 132.33,30.73 B14.N2 | v258.06,6.86 268.22,17.02 270.76,17.02 B03.T2
  2 0.305: v183.9,31.75 194.82,31.75 200.91,37.85 207.26,37.85 | 207.26,37.85 214.88,37.85 216.15,36.58 v215.9,36.32 | 207.26,37.85 213.61,44.2 214.63,44.2 215.14,44.7 224.54,44.7 258.57,78.74 259.59,78.74 261.11,80.26 261.87,80.26 264.41,82.8 264.41,83.31 267.97,86.87 270.76,86.87 A03.T2
  15 0.305: v153.16,41.15 168.66,41.15 175.51,34.29 176.53,34.29 178.82,32 183.64,32 v183.9,31.75 | v258.06,6.86 258.06,7.37 246.63,18.8 242.82,18.8 240.79,20.83 239.27,20.83 230.89,29.21 229.87,29.21 227.58,31.5 226.06,31.5 224.54,33.02 B07.M2
  Bottom 0.305: v215.9,36.32 216.66,35.56 219.71,35.56 220.22,35.05 222,35.05 223.27,33.78 B07.M2
P_WCOV  (via drill 0.61)
  Top 0.305: v157.99,2.03 166.12,2.03 167.13,1.02 184.91,1.02 187.2,3.3 189.48,3.3 v209.55,23.37
  2 0.305: B07.T2 221.23,18.03 225.55,18.03 226.31,18.8 232.66,18.8 242.32,28.45 247.65,28.45 248.67,27.43 B05.P2 | v205.99,44.7 217.93,56.64 218.44,56.64 229.87,68.07 229.87,69.34 236.22,75.69 236.22,78.49 238.25,80.52 238.25,81.53 239.27,82.55 239.27,83.06 248.67,92.46 248.67,96.27 A05.P2
  15 0.305: v205.99,44.7 204.98,43.69 207.52,41.15 207.52,38.86 209.3,37.08 209.3,33.27 209.8,32.77 209.8,23.62 v209.55,23.37
  Bottom 0.305: v157.99,2.03 147.83,12.19 146.81,12.19 146.05,12.95 140.72,12.95 123.95,29.72 119.63,29.72 B15.N2 | v209.55,23.37 212.85,23.37 216.92,19.3 218.44,19.3 219.96,17.78 B07.T2
VCC  (via drill 0.61)
  Top 0.508: A07.A2 224.54,135.38 224.79,135.38 231.65,142.24 240.54,142.24 241.81,140.97 236.47,135.64 A06.A2 | A12.A2 161.04,135.38 163.83,135.38 165.61,137.16 170.69,137.16 172.47,135.38 A11.A2 173.74,134.87 182.37,143.51 185.67,140.21 185.67,135.64 A10.A2 185.17,134.37 183.13,134.37 168.4,119.63 168.4,113.79 v166.88,112.27 | v217.68,140.97 217.42,140.97 211.84,135.38 A08.A2 | v27.43,71.37 21.59,65.53 21.34,65.53 B23.A2 | v38.35,68.58 37.08,68.58 34.04,65.53 B22.A2 | v49.78,67.56 48.77,67.56 46.74,65.53 B21.A2 | v64.01,68.33 62.23,68.33 59.44,65.53 B20.A2 | v76.45,70.1 76.45,69.85 72.14,65.53 B19.A2 | v90.17,70.36 89.66,70.36 84.84,65.53 B18.A2 | v114.3,72.64 109.98,68.33 109.98,65.79 B16.A2 | v143.51,63.75 146.3,63.75 B13.A2 148.34,65.28 152.15,69.09 v155.7,65.53 | v180.59,68.33 177.8,65.53 173.74,65.53 B11.A2 | B10.A2 186.18,65.79 191.01,70.61 v192.79,70.61 193.04,70.36 197.36,74.68 v201.42,74.68 | v216.66,68.33 214.63,68.33 211.84,65.53 B08.A2 | v228.85,69.85 224.54,65.53 B07.A2 | v166.62,71.37 161.04,65.79 161.04,65.53 B12.A2 | v103.38,71.12 97.79,65.53 97.54,65.53 B17.A2
  2 0.508: B15.A2 122.68,64.52 124.21,62.99 124.46,63.25 133.1,63.25 B14.A2
  Bottom 0.508: A08.A2 210.57,135.13 204.72,140.97 199.14,135.38 A09.A2 197.87,135.38 195.33,135.38 191.52,139.19 186.69,139.19 184.66,141.22 183.64,141.22 181.86,139.45 185.67,135.64 A10.A2 | v217.68,140.97 223.27,135.38 A07.A2 | v27.43,71.37 33.02,65.79 B22.A2 | v38.35,68.58 41.4,65.53 45.47,65.53 B21.A2 | v49.78,67.56 50.04,67.31 53.59,67.31 55.37,65.53 58.17,65.53 B20.A2 | v64.01,68.33 66.8,65.53 70.87,65.53 B19.A2 | v76.45,70.1 81.03,65.53 83.57,65.53 B18.A2 | v90.17,70.36 95,65.53 96.27,65.53 B17.A2 | v114.3,72.64 114.55,72.64 121.67,65.53 B15.A2 | v143.51,63.75 140.46,63.75 139.45,64.77 135.64,64.77 B14.A2 | v155.7,65.53 159.77,65.53 B12.A2 | v180.59,68.33 182.37,68.33 185.17,65.53 B10.A2 | v192.79,70.61 197.87,65.53 B09.A2 | B08.A2 210.57,65.53 v201.42,74.68 198.37,77.72 196.85,77.72 195.07,79.5 194.56,79.5 174.5,99.57 174.5,103.89 166.88,111.51 v166.88,112.27 | v216.66,68.33 219.46,65.53 223.27,65.53 B07.A2 | v228.85,69.85 231.39,69.85 235.71,65.53 235.97,65.53 B06.A2 | v166.62,71.37 172.47,65.53 B11.A2 | v103.38,71.12 108.97,65.53 B16.A2

## Text on the board
Bottom: VRS | DW08A | DW08A