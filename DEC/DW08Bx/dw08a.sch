# EAGLE board dw08a (EAGLE 4.11), part 2 of 3
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
N_MBINCR  (via drill 0.61) (continued)
  Top 0.305: v53.09,77.72 53.09,82.8 53.85,83.57 53.85,85.34 55.12,86.61 A20.T2
  Bottom 0.305: v53.09,77.72 53.59,77.22 53.59,73.41 71.12,55.88 71.12,53.09 B19.E2
N_RUN
  15 0.305: A18.S2 84.84,90.93 87.88,90.93 91.19,94.23 93.22,92.2 93.73,92.2 95,90.93 95,90.42 128.02,57.4 129.54,57.4 131.06,55.88 B14.D2
N_SKIP  (via drill 0.61)
  Top 0.305: v72.9,68.07 72.9,69.6 93.73,90.42 v93.98,90.42
  Bottom 0.305: v72.9,68.07 78.74,62.23 78.74,61.21 83.82,56.13 83.82,53.09 B18.E2 | v93.98,90.42 93.98,91.44 92.2,93.22 92.2,99.57 85.85,105.92 85.85,107.7 84.58,108.97 A18.K2
N_TS1
  15 0.305: A14.T2 132.33,87.88 132.33,92.2 134.11,93.98 133.35,94.74 133.35,97.28 135.64,99.57 140.46,94.74 141.48,94.74 188.47,47.75 192.28,47.75 196.6,43.43 196.6,41.91 198.12,40.39 B09.K2
N_TS3  (via drill 0.61)
  Top 0.305: v158.24,76.45 165.86,76.45 v166.12,76.71
  Bottom 0.305: v158.24,76.45 151.89,82.8 147.07,82.8 139.7,90.17 135.64,90.17 A14.S2 | v166.12,76.71 172.21,76.71 173.99,74.93 177.8,74.93 193.55,59.18 193.55,57.4 194.82,56.13 B09.D2
N_TT_INST  (via drill 0.61)
  Top 0.305: v90.68,92.2 90.42,91.95 89.92,91.95 85.85,87.88 81.53,87.88 A18.T2
  15 0.305: v90.68,92.2 117.35,65.53 117.35,55.88 117.6,55.63 117.6,55.12 131.32,41.4 133.1,41.4 134.37,40.13 B14.K2
N_WCOV  (via drill 0.61)
  2 0.305: v82.8,36.58 90.42,28.96 92.96,31.5 103.89,31.5 104.9,32.51 105.41,32.51 105.66,32.77 106.93,32.77 108.97,34.8 115.32,34.8 118.36,37.85 120.4,37.85 B15.K2
  Bottom 0.305: v82.8,36.58 72.9,46.48 72.9,52.83 71.88,53.85 71.88,56.13 54.36,73.66 54.36,77.47 54.1,77.72 54.1,78.23 35.81,96.52 34.04,96.52 A22.P2
P_3CYCLE  (via drill 0.61)
  Top 0.305: v206.76,59.44 207.52,59.44 209.3,61.21 209.3,65.79 213.36,69.85 213.36,71.63 225.3,83.57 225.3,88.9 226.06,89.66 226.06,90.68 228.35,92.96 228.35,97.03 229.62,98.3 230.63,98.3 231.9,99.57 231.9,101.85 235.46,105.41 235.46,106.17 v237.24,107.95 | v167.64,2.03 177.8,2.03 v194.82,19.05
  2 0.305: v231.9,24.64 238.51,31.24 238.51,32.26 239.01,32.77 241.05,32.77 241.55,33.27 241.55,34.04 246.63,39.12 248.67,39.12 B05.K2 | v219.2,33.78 v222.25,30.73 225.3,27.69 225.3,26.42 220.98,22.1 204.22,22.1 201.68,19.56 200.66,19.56 200.15,19.05 v194.82,19.05
  15 0.305: v231.9,24.64 229.11,24.64 224.54,29.21 223.77,29.21 v222.25,30.73 | v219.2,33.78 220.22,34.8 219.71,35.31 219.71,35.56 219.2,36.07 219.2,41.4 209.04,51.56 209.04,52.58 206.5,55.12 206.5,56.64 208.03,58.17 v206.76,59.44 | v244.09,104.9 244.09,107.7 247.4,111 248.67,109.73 A05.K2 | v109.47,9.4 147.57,9.4 147.83,9.14 152.91,9.14 161.04,1.02 166.62,1.02 v167.64,2.03
  Bottom 0.305: v237.24,107.95 241.05,107.95 v244.09,104.9 | v109.47,9.4 109.22,9.65 105.92,9.65 84.33,31.24 83.31,31.24 71.88,42.67 71.88,43.69 70.1,45.47 70.1,46.48 68.58,48.01 68.58,48.51 B19.F2
P_AC00  (via drill 0.61)
  Top 0.305: v100.08,66.29 100.33,66.29 127.76,93.73 128.78,93.73 130.81,95.76 131.83,95.76 150.11,114.05 153.42,114.05 v153.67,114.3 | v222.25,122.43 222.25,122.68 227.08,127.51 227.33,127.51 228.85,129.03 228.85,129.29 229.62,130.05 233.68,130.05 241.81,138.18 243.08,138.18 246.63,141.73 252.98,141.73 253.24,141.99 282.45,141.99 292.61,131.83 291.08,130.3 290.07,130.3 | 290.07,130.3 287.53,130.3 280.92,136.91 279.65,135.64 279.65,133.6 A03.B1 | v299.72,95 296.93,97.79 298.2,99.06 298.2,104.65 v303.28,109.73 | 290.07,130.3 v290.07,129.29
  2 0.305: v183.64,88.9 186.44,88.9 200.91,103.38 201.68,103.38 219.96,121.67 221.49,121.67 v222.25,122.43 | v299.72,95 299.21,94.49 299.21,92.2 295.4,88.39 295.4,87.88 295.15,87.63 295.15,83.82 294.89,83.57 294.89,83.06 282.45,70.61 280.92,70.61 278.38,68.07 278.38,62.48 B03.B1
  Bottom 0.305: v100.08,66.29 105.92,60.45 105.92,56.13 B16.D2 | v153.67,114.3 166.12,101.85 170.94,101.85 183.64,89.15 v183.64,88.9 | v303.28,109.73 303.28,110.74 301.75,112.27 301.75,116.59 297.18,121.16 297.18,122.17 v290.07,129.29
P_AC01  (via drill 0.61)
  2 0.305: v149.1,15.75 159.77,15.75 191.52,47.5 204.22,47.5 210.57,53.85 211.33,53.85 v211.58,54.1 | v218.69,47.75 222.76,47.75 237.49,62.48 237.49,62.74 239.27,64.52 240.28,64.52 242.32,66.55 243.08,66.55 v249.68,73.15 | v270.51,56.9 275.08,56.9 276.61,55.37 277.11,55.88 B03.D1 | v247.65,75.18 251.97,79.5 252.98,79.5 255.02,81.53 257.3,81.53 274.83,99.06 274.83,100.58 277.88,103.63 278.13,103.63 279.91,105.41 281.43,105.41 281.94,105.92 281.94,106.17 284.73,108.97 284.73,110.24 290.32,115.82 290.32,116.84 282.19,124.97 278.38,124.97 A03.D1
  15 0.305: v249.68,73.15 251.71,73.15 267.46,57.4 270,57.4 v270.51,56.9
  Bottom 0.305: v149.1,15.75 123.44,41.4 118.62,41.4 111.25,48.77 106.93,48.77 B16.F2 | v211.58,54.1 212.34,54.1 v218.69,47.75 | v249.68,73.15 v247.65,75.18
P_AC02  (via drill 0.61)
  Top 0.305: v114.3,38.61 115.57,37.34 v154.18,75.95 | v164.59,67.82 164.85,67.82 176.78,79.76 177.04,79.76 177.55,80.26 177.55,84.33 197.87,104.65 198.37,104.65 199.39,105.66 199.39,106.17 200.91,107.7 201.42,107.7 v202.95,109.22 | v287.78,127 284.73,123.95 282.96,123.95 281.69,122.68 A03.E1 | v276.1,57.4 276.61,57.4 283.72,64.52 283.72,64.77 285.24,66.29 285.24,66.8 v293.12,74.68 | v272.8,95.25 270.76,97.28 272.8,99.31 272.8,105.66 276.86,109.73 276.86,109.98 278.38,111.51 278.64,111.51 282.45,115.32 282.45,117.35 v282.7,117.6
  2 0.305: v202.95,113.79 202.95,117.35 211.33,125.73 211.33,126.24 214.12,129.03 215.65,129.03 219.96,133.35 219.96,133.86 220.47,134.37 221.23,134.37 223.27,136.4 226.57,136.4 228.35,138.18 241.81,138.18 243.08,139.45 245.36,139.45 246.89,140.97 252.22,140.97 253.24,141.99 275.84,141.99 289.31,128.52 v287.78,127
  15 0.305: v202.95,109.22 v202.95,113.79 | v276.1,57.4 276.61,56.9 278.38,56.9 280.67,54.61 280.67,53.09 B03.E1
  Bottom 0.305: v114.3,38.61 105.92,46.99 104.9,45.97 104.9,44.7 105.92,43.69 105.92,43.43 B16.J2 | v154.18,75.95 156.46,75.95 v164.59,67.82 | v293.12,74.68 293.12,74.93 v272.8,95.25 | v282.7,117.6 282.7,120.4 281.43,121.67 A03.E1
P_AC03  (via drill 0.61)
  Top 0.305: v143.76,71.88 108.97,37.08 106.93,37.08 B16.L2 | v187.2,119.38 187.2,120.4 201.17,134.37 201.42,134.37 201.93,134.87 201.93,136.91 v207.01,141.99 | v215.65,134.87 215.65,135.13 216.92,136.4 220.22,136.4 v225.3,141.48 | v279.4,113.79 279.4,114.3 A03.H1
  2 0.305: v137.41,78.74 138.18,79.5 140.97,79.5 159.77,98.3 165.1,98.3 178.56,111.76 179.58,111.76 v187.2,119.38 | v303.78,73.66 296.42,66.29 296.42,64.52 292.86,60.96 292.1,60.96 289.56,58.42 289.56,57.91 289.31,57.66 289.31,56.9 288.29,55.88 287.27,56.9 283.46,56.9 282.45,55.88 282.45,51.82 281.43,50.8 281.43,46.74 B03.H1
  15 0.305: v293.37,92.96 293.37,93.22 288.29,98.3 288.29,100.33 286,102.62 286,107.19 v279.4,113.79
  Bottom 0.305: v143.76,71.88 137.67,77.98 137.67,78.49 v137.41,78.74 | v207.01,141.99 208.53,141.99 v215.65,134.87 | v225.3,141.48 227.33,143.51 241.55,143.51 247.4,137.67 250.95,137.67 261.37,127.25 265.18,127.25 269.75,122.68 272.29,122.68 277.37,117.6 279.15,117.6 280.42,116.33 A03.H1 | v303.78,73.66 303.78,78.49 298.7,83.57 298.7,87.63 v293.37,92.96
P_AC04  (via drill 0.61)
  Top 0.305: v200.66,6.1 204.98,6.1 210.57,11.68 v210.57,11.94 | v296.42,96.77 295.66,96.77 v289.05,90.17
  2 0.305: v147.83,3.3 148.08,3.05 148.59,3.56 156.97,3.56 157.48,4.06 198.63,4.06 v200.66,6.1 | v235.71,2.03 243.84,2.03 245.36,3.56 248.41,3.56 250.44,5.59 250.44,6.1 260.86,16.51 260.86,17.53 263.4,20.07 263.4,25.15 273.81,35.56 274.83,35.56 277.11,37.85 280.67,37.85 v280.92,38.1 | v298.45,80.77 298.45,80.52 297.43,79.5 296.42,79.5 284.48,67.56 284.48,65.53 283.72,64.77 283.72,63.5 282.7,62.48 282.7,57.15 281.69,56.13 281.69,55.12 279.65,53.09 279.65,44.7 B03.J1
  15 0.305: v296.42,96.77 292.61,100.58 292.61,102.36 278.38,116.59 276.61,114.81 276.61,113.79 277.11,113.28 277.11,113.03 A03.J1
  Bottom 0.305: v147.83,3.3 138.18,12.95 121.67,12.95 106.68,27.94 106.68,29.46 B16.N2 | v210.57,11.94 211.58,11.94 213.87,9.65 217.17,9.65 220.47,6.35 225.81,6.35 228.85,3.3 229.87,3.3 232.16,1.02 234.7,1.02 v235.71,2.03 | v280.92,38.1 280.67,38.1 279.65,39.12 279.65,39.62 278.13,41.15 278.13,42.16 B03.J1 | v289.05,90.17 289.56,90.17 298.2,81.53 298.2,81.03 v298.45,80.77
P_AC05  (via drill 0.61)
  Top 0.305: v119.38,31.75 119.13,31.5 118.36,31.5 111.25,24.38 106.93,24.38 B16.R2 | v204.22,1.52 208.79,1.52 210.06,2.79 212.09,2.79 213.87,4.57 214.88,4.57 217.93,7.62 219.2,7.62 v222.25,10.67 | v147.32,100.84 141.99,95.5 137.92,95.5 123.95,81.53 123.95,78.99 120.65,75.69 120.65,72.9 v97.28,49.53
  2 0.305: v250.44,2.03 251.46,3.05 252.48,3.05 259.33,9.91 259.59,9.91 260.1,10.41 260.1,14.73 261.62,16.26 261.62,17.27 264.16,19.81 264.16,20.83 266.45,23.11 266.45,27.18 274.07,34.8 275.84,34.8 277.11,36.07 B03.L1 | v256.54,114.55 262.64,114.55 267.21,119.13 275.08,111.25 277.62,111.25 278.89,109.98 278.89,108.97 278.38,108.46 278.38,106.93 A03.L1 | v213.11,142.24 208.53,142.24 208.03,141.73 208.03,141.48 207.52,140.97 203.96,140.97 203.71,140.72 200.91,140.72 194.82,134.62 193.8,134.62 192.79,133.6 180.09,133.6 v147.32,100.84
  15 0.305: v119.38,31.75 134.62,31.75 153.42,12.95 157.23,12.95 165.35,4.83 194.31,4.83 196.09,3.05 202.69,3.05 v204.22,1.52 | v256.54,114.55 252.98,114.55 249.68,117.86 249.17,117.86 240.28,126.75 236.47,126.75 231.9,131.32 231.14,131.32 229.36,133.1 222.76,133.1 221.49,134.37 220.98,134.37 v213.11,142.24
  Bottom 0.305: v222.25,10.67 224.54,10.67 226.31,8.89 228.35,8.89 231.9,5.33 233.93,5.33 237.49,1.78 245.11,1.78 245.36,1.52 249.94,1.52 v250.44,2.03 | v97.28,49.53 97.79,49.53 108.97,38.35 112.78,38.35 v119.38,31.75
P_AC06  (via drill 0.61)
  Top 0.305: v280.92,78.49 280.92,77.72 274.07,70.87 274.07,68.83 265.68,60.45 261.62,60.45 254.25,53.09 v254.25,50.04
  2 0.305: v172.72,114.05 169.16,114.05 168.4,113.28 166.37,113.28 160.78,107.7 156.46,107.7 131.83,83.06 130.81,83.06 123.95,76.2 121.16,76.2 117.09,72.14 115.32,72.14 109.98,66.8 106.68,66.8 106.17,66.29 106.17,66.04 96.27,56.13 94.23,56.13 B17.D2 | v251.97,44.45 254,44.45 255.27,43.18 256.54,43.18 v257.05,43.69
  15 0.305: v172.72,114.05 179.32,114.05 185.17,108.2 190.5,108.2 207.26,91.44 208.28,91.44 220.22,79.5 224.03,79.5 238,65.53 238,61.72 240.79,58.93 240.79,57.66 252.22,46.23 252.22,44.7 v251.97,44.45 | v280.92,78.49 280.67,78.74 280.67,81.28 273.56,88.39 273.56,89.41 273.3,89.66 273.3,90.93 272.29,91.95 273.3,92.96 274.32,92.96 274.57,92.71 275.34,92.71 277.11,90.93 282.45,96.27 282.45,97.28 281.43,98.3 281.43,102.62 A03.M1
  Bottom 0.305: 258.83,45.47 262.13,48.77 272.29,38.61 272.29,38.1 286,24.38 287.27,24.38 289.56,26.67 284.73,31.5 283.21,31.5 281.69,33.02 B03.M1 | v257.05,43.69 258.83,45.47 | 258.83,45.47 v254.25,50.04
P_AC07  (via drill 0.61)
  Top 0.305: v118.62,75.18 116.84,73.41 116.84,70.36 97.54,51.05 97.28,51.05 96.01,49.78 94.23,49.78 B17.F2 | v185.67,25.15 188.21,25.15 200.91,37.85 205.23,37.85 220.73,53.34 221.23,53.34 224.79,56.9 225.04,56.9 | 225.04,56.9 227.33,56.9 v228.35,57.91 | v252.98,88.9 255.02,86.87 225.04,56.9
  15 0.305: v253.24,34.04 255.27,36.07 257.3,36.07 258.32,35.05 264.67,35.05 274.07,25.65 277.88,25.65 280.92,22.61 281.94,22.61 282.7,23.37 282.7,25.15 281.43,26.42 B03.P1 | v252.98,88.9 251.97,89.92 251.97,91.44 250.7,92.71 250.7,97.28 250.44,97.54 251.46,98.55 252.48,98.55 252.73,98.3 253.75,99.31 253.75,99.57 254.25,100.08 255.27,100.08 257.05,98.3 262.38,98.3 262.64,98.04 265.43,98.04 272.03,104.65 275.08,104.65 276.1,103.63 278.89,103.63 279.4,103.12 279.4,102.87 280.67,101.6 280.67,97.54 A03.P1
  Bottom 0.305: v118.62,75.18 120.14,75.18 121.16,74.17 123.95,74.17 134.37,63.75 139.45,63.75 140.21,62.99 141.48,62.99 169.42,35.05 175.77,35.05 v185.67,25.15 | v228.35,57.91 229.11,57.91 229.62,57.4 233.43,57.4 238,52.83 238,48.01 251.71,34.29 252.98,34.29 v253.24,34.04
P_AC08  (via drill 0.61)
  Top 0.305: v133.35,17.27 135.89,17.27 147.07,28.45 157.73,28.45 159.26,29.97 160.27,29.97 162.56,32.26 165.86,32.26 167.89,30.23 169.16,31.5 174.24,31.5 187.71,44.96 188.98,44.96 191.52,47.5 201.93,47.5 218.19,63.75 v218.44,63.75 | v253.24,40.13 253.24,39.37 252.73,38.86 | 252.73,38.86 250.95,37.08 v250.95,32.26 | v278.64,13.21 278.64,15.24 280.42,17.02 280.42,20.07 B03.S1 | v283.97,58.67 283.46,58.67 283.21,58.42 282.7,58.42 278.38,54.1 274.07,54.1 268.99,49.02 267.97,49.02 256.54,37.59 256.03,37.59 255.52,37.08 254.51,37.08 252.73,38.86
  2 0.305: v295.4,73.91 294.13,73.91 286,65.79 286,60.71 v283.97,58.67
  Bottom 0.305: v133.35,17.27 133.6,17.02 132.59,16 131.32,16 128.78,18.54 127.76,18.54 107.95,38.35 96.27,38.35 93.98,40.64 93.98,42.16 B17.J2 | v218.44,63.75 225.55,63.75 227.08,65.28 242.06,50.29 243.08,50.29 v253.24,40.13 | v250.95,32.26 252.98,32.26 254.51,30.73 255.02,30.73 261.37,24.38 262.64,24.38 264.67,22.35 269.49,22.35 v278.64,13.21 | v295.4,73.91 281.43,87.88 281.43,89.92 A03.S1
P_AC09  (via drill 0.61)
  Top 0.305: v111.25,33.53 111.25,37.85 148.08,74.68 148.08,76.2 155.45,83.57 155.45,89.15 v156.72,90.42 | v283.97,41.15 284.48,41.15 285.5,42.16 285.5,46.48 v286.26,47.24
  2 0.305: v168.15,93.47 167.89,93.73 169.16,95 174.5,95 184.91,105.41 185.93,105.41 188.21,107.7 193.55,107.7 194.31,108.46 195.07,108.46 197.36,110.74 197.87,110.74 198.12,111 201.93,111 206.25,115.32 206.25,119.38 210.57,123.7 214.63,123.7 216.66,125.73 217.93,125.73 226.06,133.86 227.08,133.86 229.62,136.4 247.4,136.4 v249.94,138.94 | v286.26,47.24 286.51,47.24 289.81,50.55 290.58,50.55 291.08,51.05 291.08,52.58 306.32,67.82 306.32,74.68 307.09,75.44 307.09,81.53 303.78,84.84 303.78,85.85 v306.32,88.39
  15 0.305: v156.72,90.42 162.31,96.01 165.61,96.01 v168.15,93.47 | v283.97,41.15 271.78,53.34 271.78,54.86 B03.D2 | v306.32,88.39 301.75,92.96 301.75,95.76 301.5,96.01 301.5,98.81 291.08,109.22 289.56,109.22 275.08,123.7 273.3,123.7 272.03,124.97 A03.D2
  Bottom 0.305: v111.25,33.53 109.73,35.05 99.57,35.05 98.55,36.07 94.23,36.07 B17.L2 | v249.94,138.94 254.51,143.51 255.27,143.51 269.75,129.03 269.75,127.25 271.02,125.98 A03.D2
P_AC10  (via drill 0.61)
  Top 0.305: v254.25,130.56 252.98,130.56 252.73,130.3 247.65,130.3 240.03,122.68 239.52,122.68 238.76,121.92 238.25,121.92 230.89,114.55 228.35,114.55 v228.09,114.3 | v209.55,121.16 209.55,118.62 198.12,107.19 197.87,107.19 196.6,105.92 196.6,105.66 166.62,75.69 164.85,75.69 v160.02,70.87 157.99,68.83 v157.99,63.5 | v220.73,13.46 219.71,13.46 213.61,7.37 212.09,7.37 v211.84,7.11
  2 0.305: v254.25,130.56 257.3,133.6 262.64,133.6 263.14,134.11 264.92,134.11 274.32,124.71 274.32,122.94 A03.E2 | v160.02,70.87 156.97,67.82 154.43,67.82 131.06,44.45 130.05,44.45 116.84,31.24 115.82,31.24 113.28,28.7 95.25,28.7 94.23,29.72 B17.N2 | v241.55,5.08 241.81,5.33 243.33,5.33 245.62,7.62 246.63,7.62 251.97,12.95 256.29,12.95 260.1,16.76 260.1,17.78 260.6,18.29 260.6,27.69 269.75,36.83 269.75,39.12 273.3,42.67 273.3,46.74 274.07,47.5 274.07,51.82 B03.E2
  15 0.305: v211.84,7.11 211.84,9.14 192.53,28.45 191.01,28.45 190.25,29.21 190.25,30.73 167.13,53.85 163.32,53.85 162.05,55.12 162.05,59.44 v157.99,63.5
  Bottom 0.305: v228.09,114.3 223.27,114.3 211.84,125.73 211.84,126.24 210.82,127.25 209.55,127.25 208.79,126.49 209.3,125.98 209.3,121.41 v209.55,121.16 | v241.55,5.08 235.2,5.08 227.84,12.45 221.74,12.45 v220.73,13.46
P_AC11  (via drill 0.61)
  Top 0.305: v102.87,16 108.2,16 108.71,16.51 109.73,16.51 131.06,37.85 134.87,37.85 135.13,38.1 143,38.1 143.51,38.61 144.78,38.61 v145.03,38.86 | v194.06,75.44 195.58,75.44 198.37,78.23 198.37,79.76 204.22,85.6 207.77,85.6 v208.53,84.84 | v225.81,72.9 229.11,72.9 235.46,79.25 235.97,79.25 239.01,82.3 240.03,82.3 v240.28,82.55 | v249.68,92.96 247.9,91.19 247.9,85.6 v244.86,82.55
  2 0.305: v145.03,38.86 148.08,35.81 150.11,37.85 156.46,37.85 169.16,50.55 173.23,50.55 174.5,51.82 174.5,55.88 v194.06,75.44
  15 0.305: v249.68,92.96 246.38,96.27 251.46,101.35 259.33,101.35 261.37,99.31 274.07,112.01 274.07,115.32 A03.H2
  Bottom 0.305: v102.87,16 101.35,17.53 101.35,18.03 96.01,23.37 94.23,23.37 B17.R2 | v208.53,84.84 210.57,82.8 215.9,82.8 v225.81,72.9 | v240.28,82.55 241.81,82.55 243.33,81.03 | 243.33,81.03 257.05,67.31 257.05,66.8 268.73,55.12 268.73,53.85 272.8,49.78 272.8,48.26 274.32,46.74 B03.H2 | 243.33,81.03 v244.86,82.55
P_ACCEPT  (via drill 0.61)
  Top 0.305: v157.73,13.97 158.5,13.97 164.34,8.13 166.12,8.13 v167.64,9.65 | v234.95,63.25 235.2,63.5 235.2,65.79 259.33,89.92 261.37,89.92 A04.S2 | v239.78,58.42 239.78,57.66 238.25,56.13 238.25,52.58 v239.27,51.56 | v261.87,25.4 261.87,21.34 B04.S2
  2 0.305: v167.64,9.65 209.8,9.65 210.06,9.91 211.07,9.91 219.96,18.8 222,18.8 B07.S2
  15 0.305: v248.41,2.54 249.94,1.02 272.29,1.02 277.88,6.6 265.68,18.8 264.16,18.8 262.64,20.32 B04.S2
  Bottom 0.305: v248.41,2.54 242.06,8.89 239.01,8.89 232.16,15.75 231.14,15.75 230.89,16 226.57,16 224.28,18.29 224.28,20.07 B07.S2 | v157.73,13.97 152.4,19.3 147.07,19.3 122.68,43.69 122.68,45.47 B15.H2 | v239.78,58.42 v234.95,63.25 | v239.27,51.56 257.05,33.78 257.05,29.97 261.62,25.4 v261.87,25.4
P_ACCLR  (via drill 0.61)
  Top 0.305: v202.69,44.45 203.96,43.18 197.87,37.08 v197.61,37.08
  2 0.305: v254.76,2.29 255.27,2.79 256.54,2.79 259.84,6.1 264.41,6.1 273.3,14.99 273.3,21.34 274.07,22.1 274.07,26.42 B03.P2 | v212.09,16.76 209.3,16.76 208.53,16 202.18,16 199.14,12.95 169.67,12.95 168.4,11.68 166.12,11.68 164.08,9.65 135.13,9.65 v127.51,2.03 | v245.36,67.06 256.03,77.72 256.54,77.72 258.32,79.5 259.33,79.5 260.35,80.52 260.35,81.79 261.37,82.8 262.64,82.8 268.99,89.15 270.51,89.15 271.02,89.66 271.02,89.92 272.8,91.69 272.8,92.46 273.81,93.47 273.81,95.25 274.07,95.5 274.07,96.27 A03.P2 | v243.84,57.4 239.52,57.4 231.9,49.78 231.9,48.77 233.43,47.24 234.95,48.77 v234.95,49.02 | v197.61,86.61 196.6,86.61 184.15,74.17 184.15,72.64 v181.1,69.6
  15 0.305: v254.76,2.29 253.24,2.29 252.48,3.05 250.44,3.05 249.94,3.56 232.92,3.56 230.12,6.35 224.54,6.35 221.74,9.14 220.73,9.14 216.15,13.72 216.15,14.48 214.88,15.75 213.11,15.75 v212.09,16.76 | v245.36,67.06 245.36,63.25 243.33,61.21 243.33,60.2 244.35,59.18 244.35,57.91 v243.84,57.4 | v234.95,49.02 234.95,48.51 232.92,46.48 214.88,64.52 213.61,64.52 211.58,66.55 211.07,66.55 209.55,68.07 209.55,77.22 200.15,86.61 v197.61,86.61 | v181.1,69.6 181.1,69.34 181.61,68.83 181.61,67.31 189.99,58.93 189.99,57.15 v202.69,44.45
  Bottom 0.305: v127.51,2.03 123.7,2.03 84.58,41.15 82.8,41.15 81.53,42.42 B18.J2 | v197.61,37.08 197.61,36.07 199.9,33.78 199.9,32.51 198.88,31.5 198.88,28.45 199.9,27.43 201.42,27.43 v212.09,16.76
P_ADD00  (via drill 0.61)
  Top 0.305: v63.75,47.5 68.58,47.5 82.3,61.21 82.3,65.28 88.9,71.88 89.15,71.88 98.81,81.53 98.81,81.79 131.06,114.05 141.48,114.05 145.8,118.36 145.8,122.43 159.77,136.4 163.32,136.4 v164.34,137.41 | v220.98,133.35 220.98,134.11 v228.85,141.99 | v259.84,127 262.38,127 263.4,128.02 263.4,129.79 264.67,131.06 A04.B1 | v260.6,70.36 258.06,70.36 v252.48,64.77 | v240.79,76.96 240.79,80.01 244.35,83.57 244.35,88.9 245.11,89.66 245.11,90.68 247.4,92.96 247.4,97.03 255.02,104.65 257.56,104.65 v257.81,104.9
  2 0.305: v164.34,137.41 177.8,137.41 178.31,137.92 182.88,137.92 184.15,139.19 193.8,139.19 195.83,141.22 198.37,141.22 198.88,141.73 204.72,141.73 v205.99,143
  15 0.305: v257.81,104.9 260.6,104.9 265.68,109.98 267.46,108.2 268.99,108.2 273.3,112.52 273.3,119.13 269.24,123.19 269.24,125.22 264.92,129.54 264.92,131.06 A04.B1
  Bottom 0.305: v63.75,47.5 63.5,47.75 61.47,47.75 55.88,53.34 55.88,54.86 B20.D2 | v205.99,143 210.82,143 212.6,141.22 213.11,141.22 v220.98,133.35 | v228.85,141.99 229.62,142.75 241.3,142.75 247.14,136.91 249.94,136.91 v259.84,127 | v260.6,70.36 264.67,66.29 264.67,62.48 B04.B1 | v252.48,64.77 241.05,76.2 241.05,76.71 v240.79,76.96
P_ADD01  (via drill 0.61)
  Top 0.305: v104.39,7.37 109.98,7.37 111,8.38 114.3,8.38 115.32,9.4 144.78,9.4 145.8,10.41 145.8,16 v150.11,20.32 | v193.04,3.05 207.26,3.05 207.77,3.56 211.07,3.56 219.96,12.45 224.03,12.45 225.3,13.72 225.3,14.48 226.82,16 227.58,16 v255.78,44.2 | v257.3,122.68 257.3,125.98 265.18,133.86 266.95,132.08 266.95,129.54 265.68,128.27 265.68,125.98 A04.D1 | v219.71,137.41 216.66,137.41 204.22,124.97 204.22,123.7 197.1,116.59 v197.1,114.81 | v169.93,139.7 156.46,139.7 133.35,116.59 131.32,116.59 v93.73,78.99 | v82.04,82.3 73.91,82.3 65.02,73.41 65.02,67.06 57.4,59.44 57.4,51.05 B20.F2
  2 0.305: v246.89,57.15 252.73,57.15 254,55.88 254.25,56.13 257.3,56.13 258.06,56.9 263.4,56.9 264.41,55.88 B04.D1
  15 0.305: v257.3,122.68 257.05,122.68 256.03,123.7 252.22,123.7 242.06,133.86 239.52,133.86 236.98,136.4 220.73,136.4 v219.71,137.41
  Bottom 0.305: v104.39,7.37 102.11,9.65 99.57,9.65 82.55,26.67 81.53,26.67 59.44,48.77 56.13,48.77 B20.F2 | v150.11,20.32 154.43,24.64 156.72,22.35 162.05,22.35 165.86,18.54 166.88,18.54 169.42,16 180.09,16 v193.04,3.05 | v255.78,44.2 255.52,44.2 247.9,51.82 247.9,56.13 v246.89,57.15 | v197.1,114.81 197.1,120.65 180.59,137.16 177.29,137.16 173.99,140.46 170.69,140.46 v169.93,139.7 | v93.73,78.99 85.34,78.99 v82.04,82.3
P_ADD02  (via drill 0.61)
  Top 0.305: v200.91,115.32 202.18,115.32 210.57,123.7 214.63,123.7 v232.16,141.22 | v258.32,63.5 258.32,64.52 266.19,72.39 266.19,73.66 279.15,86.61 v279.15,90.42 | v276.1,93.47 272.03,97.54 273.56,99.06 273.56,100.84 v274.32,101.6
  2 0.305: v168.15,123.7 166.12,123.7 124.71,82.3 118.36,82.3 83.57,47.5 77.22,47.5 74.68,44.96 73.66,44.96 72.9,44.2 61.21,44.2 60.45,43.43 56.13,43.43 B20.J2
  15 0.305: v168.15,123.7 188.72,123.7 191.52,120.9 195.33,120.9 v200.91,115.32
  Bottom 0.305: v232.16,141.22 233.17,141.22 234.19,140.21 234.7,140.21 243.84,131.06 243.84,130.81 245.11,129.54 246.38,129.54 255.02,120.9 260.35,120.9 264.41,116.84 265.43,116.84 266.95,115.32 | 266.95,115.32 267.72,114.55 268.99,114.55 270.26,115.82 266.19,119.89 266.19,120.9 267.72,122.43 A04.E1 | v258.32,63.5 258.57,63.25 259.33,63.25 267.97,54.61 267.97,53.09 B04.E1 | v276.1,93.47 v279.15,90.42 | v274.32,101.6 266.95,108.97 266.95,115.32
P_ADD03  (via drill 0.61)
  Top 0.305: v77.98,22.35 87.88,22.35 145.8,80.26 145.8,84.33 159.77,98.3 160.78,98.3 161.8,97.28 161.8,96.52 163.07,95.25 166.12,98.3 172.47,98.3 186.18,112.01 | 186.18,112.01 215.14,140.97 215.39,140.97 v217.68,143.26 | v228.85,132.08 230.89,132.08 v240.03,141.22 | v237.24,77.98 235.2,77.98 v229.11,71.88 | 186.18,112.01 v187.96,110.24
  15 0.305: v237.24,77.98 237.49,77.72 238,77.72 244.86,70.87 245.36,70.87 251.46,64.77 251.46,64.26 252.48,63.25 252.98,63.25 266.7,49.53 266.7,48.51 267.97,47.24 267.97,46.74 B04.H1
  Bottom 0.305: v77.98,22.35 65.28,35.05 61.47,35.05 60.45,36.07 56.13,36.07 B20.L2 | v217.68,143.26 v228.85,132.08 | v240.03,141.22 241.05,141.22 264.67,117.6 266.45,117.6 267.72,116.33 A04.H1 | v229.11,71.88 228.35,71.88 226.31,73.91 225.81,73.91 212.34,87.38 211.84,87.38 211.07,88.14 210.06,88.14 v187.96,110.24
P_ADD04  (via drill 0.61)
  Top 0.305: v76.2,18.29 79.76,18.29 80.26,18.8 85.6,18.8 v152.4,85.6 | v252.48,28.19 264.67,40.39 264.67,42.16 B04.J1
  2 0.305: v190.75,60.45 191.77,60.45 194.56,63.25 198.63,63.25 199.64,64.26 201.68,64.26 202.69,65.28 | 202.69,65.28 205.23,67.82 206.5,67.82 217.17,78.49 220.22,78.49 225.3,83.57 225.3,87.63 235.97,98.3 238.25,98.3 240.28,96.27 251.71,107.7 256.03,107.7 256.29,107.95 257.05,107.95 258.06,108.97 259.33,108.97 261.37,111 263.14,111 264.41,112.27 A04.J1 | v252.48,28.19 249.94,25.65 243.84,25.65 v242.32,24.13 | 202.69,65.28 v201.68,66.29
  Bottom 0.305: v76.2,18.29 65.79,28.7 61.47,28.7 60.45,29.72 56.13,29.72 B20.N2 | v152.4,85.6 155.7,85.6 168.66,72.64 172.21,72.64 173.48,71.37 176.02,71.37 180.09,67.31 181.61,67.31 188.47,60.45 v190.75,60.45 | v242.32,24.13 241.3,24.13 240.28,25.15 240.03,25.15 238,27.18 238,27.43 233.17,32.26 232.92,32.26 232.41,32.77 232.41,34.29 223.77,42.93 223.77,44.2 v201.68,66.29
P_ADD05  (via drill 0.61)
  Top 0.305: v232.41,6.35 238.25,6.35 259.84,27.94 259.84,29.21 263.4,32.77 263.4,34.54 264.67,35.81 B04.L1 | v275.59,112.27 275.34,112.27 268.99,105.92 265.68,105.92 A04.L1
  2 0.305: v208.28,2.54 213.36,2.54 214.12,1.78 218.69,1.78 220.73,3.81 221.23,3.81 223.01,5.59 225.04,5.59 226.31,6.86 227.08,6.86 228.35,5.59 229.11,6.35 v232.41,6.35 | v289.31,103.38 289.56,103.12 284.48,98.04 284.48,97.28 278.13,90.93 278.13,89.15 279.91,87.38 272.03,79.5 270.26,79.5 264.16,73.41 264.16,71.37 260.6,67.82 260.1,67.82 v257.3,65.02 | v266.7,53.59 266.7,52.83 263.65,49.78 263.65,38.1 264.67,37.08 B04.L1
  15 0.305: v143,14.73 141.73,16 112.27,16 109.73,18.54 108.71,18.54 107.95,19.3 70.87,19.3 62.99,27.18 60.2,24.38 56.13,24.38 B20.R2 | v257.3,65.02 258.32,65.02 259.33,64.01 259.33,63.25 266.45,56.13 266.45,53.85 v266.7,53.59
  Bottom 0.305: v143,14.73 145.29,14.73 147.07,12.95 166.12,12.95 169.42,9.65 171.7,9.65 176.53,4.83 183.64,4.83 187.2,1.27 199.9,1.27 204.72,6.1 v208.28,2.54 | v275.59,112.27 276.35,112.27 277.37,111.25 281.43,111.25 v289.31,103.38
P_ADD06  (via drill 0.61)
  Top 0.305: v276.35,39.37 270.76,33.78 268.99,33.78 B04.M1
  2 0.305: v232.16,84.58 232.66,84.58 238,89.92 238,90.42 238.76,91.19 240.54,91.19 256.54,107.19 257.56,107.19 258.32,107.95 v258.57,107.95 | v124.46,134.87 45.72,56.13 43.43,56.13 B21.D2
  15 0.305: v207.52,103.12 209.3,103.12 210.57,101.85 214.38,101.85 215.65,100.58 215.65,98.81 v216.15,98.3
  Bottom 0.305: v276.35,39.37 276.35,39.88 252.98,63.25 252.48,63.25 251.46,64.26 251.46,64.77 239.27,76.96 239.27,77.47 v232.16,84.58 221.23,95.5 216.92,95.5 216.15,96.27 v216.15,98.3 | v258.57,107.95 259.08,107.95 260.86,106.17 261.37,106.17 266.95,100.58 267.97,100.58 268.99,101.6 267.97,102.62 A04.M1 | v124.46,134.87 133.1,143.51 154.69,143.51 156.72,141.48 158.24,141.48 172.47,127.25 177.04,127.25 192.79,111.51 194.56,111.51 194.82,111.25 199.39,111.25 v207.52,103.12
P_ADD07  (via drill 0.61)
  Top 0.305: v204.47,55.12 204.98,55.12 v209.8,59.94 230.63,80.77 v230.63,81.79 | v247.65,29.97 250.19,29.97 251.97,31.75 251.97,34.29 252.73,35.05 255.27,35.05 258.32,38.1 v258.57,38.1 | v261.62,78.49 257.3,78.49 256.54,77.72 255.27,77.72 251.71,74.17 249.17,74.17 v244.86,69.85
  2 0.305: v119.89,39.12 119.38,38.61 118.11,38.61 115.32,35.81 113.28,37.85 67.31,37.85 62.99,33.53 47.75,48.77 43.43,48.77 B21.F2 | v137.67,25.65 155.96,25.65 162.56,32.26 163.58,32.26 166.12,34.8 170.43,34.8 184.66,49.02 186.69,49.02 188.21,50.55 200.15,50.55 202.69,53.09 202.69,53.34 v204.47,55.12 | v260.86,91.69 265.18,96.01 265.68,96.01 265.94,96.27 267.72,96.27 A04.P1
  Bottom 0.305: v119.89,39.12 120.9,39.12 134.37,25.65 v137.67,25.65 | v209.8,59.94 210.57,59.94 211.84,61.21 219.71,53.34 219.71,52.83 221.74,50.8 222.25,50.8 235.97,37.08 237.24,37.08 239.27,35.05 243.08,35.05 247.4,30.73 247.4,30.23 v247.65,29.97 | v258.57,38.1 259.08,38.1 266.45,30.73 266.45,29.21 267.97,27.69 B04.P1 | v260.86,91.69 253.49,84.33 258.32,79.5 260.6,79.5 v261.62,78.49 | v244.86,69.85 242.57,69.85 v230.63,81.79
P_ADD08  (via drill 0.61)
  Top 0.305: v229.87,1.27 234.95,1.27 235.2,1.02 240.28,1.02 255.02,15.75 255.52,15.75 v255.78,16 | B04.S1 266.45,18.8 266.45,16.76 264.41,14.73 v264.16,14.73 264.16,14.48 261.87,12.19 260.6,13.46 260.6,14.99 263.65,18.03 263.65,24.38 281.43,42.16 v277.37,46.23 | v266.45,92.2 267.72,90.93 A04.S1 | v263.4,89.15 263.4,87.63 251.21,75.44 v251.21,75.18
  2 0.305: v201.42,1.27 202.44,2.29 203.45,2.29 203.71,2.54 205.99,2.54 207.52,1.02 222.5,1.02 224.28,2.79 228.35,2.79 v229.87,1.27 | v263.4,89.15 v266.45,92.2
  15 0.305: v73.66,25.15 103.12,25.15 108.97,19.3 131.32,19.3 131.83,18.8 141.22,18.8 147.07,12.95 152.4,12.95 153.16,12.19 154.18,12.19 156.72,9.65 159.51,9.65 165.1,4.06 194.06,4.06 195.83,2.29 200.41,2.29 v201.42,1.27 | v255.78,16 262.89,16 v264.16,14.73
  Bottom 0.305: v73.66,25.15 73.15,25.65 70.87,25.65 64.52,32 58.17,32 56.39,33.78 55.37,33.78 46.74,42.42 43.43,42.42 B21.J2 | v251.21,75.18 251.21,74.17 257.81,67.56 257.81,67.06 269.49,55.37 269.49,54.1 v277.37,46.23
P_ADD09  (via drill 0.61)
  Top 0.305: v54.1,27.18 56.9,27.18 86.61,56.9 91.95,56.9 92.71,57.66 93.73,57.66 131.06,95 134.11,95 v134.37,95.25 | v281.43,23.62 281.43,23.11 279.65,21.34 279.65,17.27 272.03,9.65 268.99,9.65 264.67,5.33 262.64,5.33 260.35,3.05 258.57,3.05 v256.79,4.83
  2 0.305: v156.97,89.15 159.77,91.95 163.83,91.95 171.2,99.31 173.48,99.31 210.57,136.4 211.07,136.4 216.92,142.24 218.95,142.24 v219.71,143 | v208.53,57.15 204.47,57.15 203.45,56.13 203.45,55.37 v201.68,53.59
  15 0.305: v219.71,143 220.22,143 220.98,142.24 223.01,142.24 224.79,140.46 229.36,140.46 229.62,140.21 242.06,140.21 255.02,127.25 256.54,127.25 258.06,125.73 A04.D2 | v281.43,23.62 279.15,25.91 279.15,30.73 272.29,37.59 272.29,38.61 267.72,43.18 267.72,44.2 259.08,52.83 259.08,54.86 B04.D2 | v256.79,4.83 256.03,5.59 254.25,5.59 253.49,6.35 253.49,7.87 244.35,17.02 243.59,17.02 240.54,20.07 239.01,20.07 230.63,28.45 226.82,28.45 222.5,32.77 222.5,39.12 209.8,51.82 209.8,55.88 v208.53,57.15 | v201.68,53.59 200.15,53.59 176.78,76.96 176.78,78.23 173.48,81.53 171.2,81.53 170.43,82.3 166.62,82.3 160.27,88.65 157.48,88.65 v156.97,89.15
  Bottom 0.305: v54.1,27.18 45.21,36.07 43.43,36.07 B21.L2 | v134.37,95.25 146.3,95.25 146.81,94.74 147.83,94.74 153.42,89.15 v156.97,89.15
P_ADD10  (via drill 0.61)
  Top 0.305: v169.16,134.62 145.54,111 140.72,111 131.83,102.11 130.81,102.11 120.65,91.95 115.32,91.95 84.33,60.96 83.31,60.96 53.85,31.5 48.51,31.5 47.75,30.73 43.43,30.73 B21.N2 | v193.8,118.11 195.07,116.84 | 195.07,116.84 v221.49,143.26 | v244.09,117.6 248.92,117.6 251.71,120.4 255.52,120.4 255.78,120.65 260.35,120.65 A04.E2 | v193.55,112.52 193.55,115.32 195.07,116.84
  2 0.305: v250.95,60.45 250.7,60.2 253.49,57.4 256.29,57.4 258.57,59.69 259.59,59.69 261.37,61.47 266.45,56.39 266.45,54.86 264.41,52.83 262.64,52.83 B04.E2
  15 0.305: v213.87,96.52 213.36,96.52 208.53,101.35 204.72,101.35 v193.55,112.52
  Bottom 0.305: v169.16,134.62 173.23,138.68 v193.8,118.11 | v221.49,143.26 221.49,140.97 232.92,129.54 232.92,128.78 v244.09,117.6 | v250.95,60.45 250.44,60.45 225.81,85.09 225.81,85.6 224.54,86.87 222.25,86.87 220.73,85.34 216.15,89.92 216.15,94.23 v213.87,96.52
P_ADD11  (via drill 0.61)
  Top 0.305: v64.77,16.51 67.56,13.72 115.32,61.47 117.35,61.47 119.63,59.18 v132.84,72.39 | v159.26,54.1 160.02,54.1 162.81,56.9 166.88,56.9 171.2,61.21 171.2,66.04 188.47,83.31 188.47,84.07 v189.99,85.6 | v265.43,108.2 264.92,108.2 257.3,100.58 257.3,96.52 256.29,95.5 252.22,95.5 250.95,94.23 v250.95,90.93 | v284.99,54.1 280.67,54.1 276.35,49.78 276.35,44.2 v270.76,38.61
  2 0.305: v239.78,44.45 239.78,44.96 242.32,47.5 246.89,47.5 250.7,51.31 254.76,51.31 260.6,45.47 261.37,46.23 B04.H2
  15 0.305: v250.95,90.93 250.95,86.87 258.32,79.5 262.13,79.5 272.29,69.34 272.29,65.53 283.72,54.1 v284.99,54.1
  Bottom 0.305: v64.77,16.51 58.93,22.35 48.77,22.35 47.75,23.37 43.43,23.37 B21.R2 | v132.84,72.39 134.62,72.39 137.92,69.09 141.73,69.09 156.72,54.1 v159.26,54.1 | v189.99,85.6 192.53,85.6 196.6,81.53 196.6,81.03 210.06,67.56 212.09,67.56 226.82,52.83 227.84,52.83 235.97,44.7 239.52,44.7 v239.78,44.45 | v265.43,108.2 262.38,111.25 262.38,115.32 A04.H2 | v270.76,38.61 270.76,39.12 265.68,44.2 264.16,44.2 262.64,45.72 B04.H2
P_BAC00  (via drill 0.61)
  Top 0.305: v205.23,75.44 192.53,62.74 194.82,60.45 195.83,60.45 197.36,61.98 199.9,59.44 199.9,58.17 195.58,53.85 191.52,53.85 186.18,48.51 186.18,46.74 B10.H2
  2 0.305: A01.B1 302.77,131.06 301.5,129.79 301.5,128.02 291.08,117.6 291.08,115.57 285.5,109.98 285.5,105.41 279.15,99.06 279.15,92.96 276.61,90.42 276.61,88.65 274.57,86.61 v274.57,85.85 274.32,85.85 273.56,85.09 272.29,85.09 268.99,81.79 268.99,79.76 262.13,72.9 262.13,71.37 261.62,70.87 261.62,69.85 260.35,68.58 v258.83,68.58 | v248.92,77.98 237.49,66.55 235.97,66.55 231.9,62.48 227.58,62.48 B07.B1
  15 0.305: v274.57,85.85 274.83,85.85 279.91,80.77 279.91,77.98 291.34,66.55 294.13,66.55 294.64,66.04 295.91,66.04 299.72,62.23 302.51,62.23 B01.B1
  Bottom 0.305: v205.23,75.44 223.27,57.4 224.54,57.4 227.58,60.45 226.82,61.21 B07.B1 | v248.92,77.98 249.94,77.98 252.22,75.69 252.22,75.18 v258.83,68.58
P_BAC01  (via drill 0.61)
  Top 0.305: v190.5,24.13 192.53,24.13 220.98,52.58 221.49,52.58 221.74,52.83 222.25,52.83 223.27,53.85 225.04,53.85 226.31,55.12 B07.D1 | v292.35,42.93 293.62,42.93 302.51,51.82 302.51,54.61 302.77,54.86 B01.D1
  2 0.305: v282.45,99.82 282.45,101.35 286.26,105.16 286.26,106.43 301.5,121.67 301.5,123.44 302.77,124.71 A01.D1 | v249.94,75.95 244.86,70.87 244.35,70.87 230.89,57.4 229.36,57.4 228.09,56.13 227.58,56.13 B07.D1
  15 0.305: v282.45,99.82 287.78,94.49 287.78,92.96 294.39,86.36 294.39,85.34 295.4,84.33 295.4,80.52 304.29,71.63 304.29,67.82 304.8,67.31 304.8,61.98 305.05,61.72 303.28,59.94 303.28,56.13 B01.D1 | v249.94,75.95 249.94,74.93 250.7,74.17 251.71,74.17 258.32,67.56 261.87,67.56 262.89,68.58 264.16,67.31 267.97,67.31 269.75,65.53 269.75,62.74 270,62.48 270,61.47 286.77,44.7 290.58,44.7 v292.35,42.93
  Bottom 0.305: v190.5,24.13 184.91,29.72 183.13,29.72 B10.N2
P_BAC02  (via drill 0.61)
  Top 0.305: v228.85,46.99 228.85,51.05 B07.E1 | v304.8,45.97 304.8,42.42 300.74,38.35 295.4,38.35 294.64,37.59 293.88,37.59 280.42,24.13 280.42,23.37 265.94,8.89 263.91,8.89 v263.4,8.38 | v302.77,74.93 302.77,72.39 v295.4,65.02
  2 0.305: v234.44,33.78 220.22,19.56 219.71,19.56 218.95,18.8 200.91,18.8 197.87,15.75 191.52,15.75 190.5,14.73 186.44,14.73 B10.U2 | v304.8,45.97 305.05,46.23 305.05,46.74 305.82,47.5 305.82,51.82 B01.E1 | v286,94.74 286,97.54 305.82,117.35 305.82,121.67 A01.E1
  15 0.305: v234.44,33.78 237.49,36.83 228.85,45.47 v228.85,46.99
  Bottom 0.305: v263.4,8.38 258.06,8.38 246.63,19.81 246.63,21.34 234.44,33.53 v234.44,33.78 | v286,94.74 300.99,79.76 300.99,76.71 v302.77,74.93 | v295.4,65.02 295.66,65.02 304.55,56.13 304.55,54.61 306.07,53.09 B01.E1
P_BAC03  (via drill 0.61)
  Top 0.305: v224.79,43.69 225.81,43.69 226.31,44.2 228.35,44.2 B07.H1 230.63,46.74 231.9,48.01 231.9,49.78 237.49,55.37 237.49,56.39 238.76,57.66 238.76,58.93 239.78,59.94 245.62,54.1 246.63,54.1 251.97,59.44 251.97,59.94 252.48,60.45 252.98,60.45 253.24,60.71 254,59.94 v254,58.42 | B11.H2 173.48,46.74 173.48,48.51 191.52,66.55 194.82,66.55 v195.07,66.8 206.5,78.23 v206.5,84.58 | v276.1,30.48 283.97,38.35 294.39,38.35 302.51,46.48 303.28,46.48 304.55,47.75 305.82,46.48 B01.H1 | v228.6,117.86 227.84,117.86 208.79,98.81 208.79,97.79 v201.42,90.42
  2 0.305: v262.64,137.67 260.35,137.67 259.84,137.16 253.49,137.16 243.59,127.25 238.25,127.25 228.85,117.86 v228.6,117.86
  15 0.305: v195.07,66.8 197.36,69.09 201.17,65.28 202.69,65.28 223.27,44.7 223.77,44.7 v224.79,43.69 | v266.95,41.15 266.95,43.94 258.32,52.58 258.32,54.1 v254,58.42
  Bottom 0.305: v276.1,30.48 275.59,30.48 266.95,39.12 v266.95,41.15 | v262.64,137.67 268.48,137.67 269.75,136.4 275.08,136.4 276.86,134.62 278.64,134.62 280.16,133.1 291.08,133.1 306.07,118.11 306.07,116.59 A01.H1 | v201.42,90.42 201.42,89.66 v206.5,84.58
P_BAC04  (via drill 0.61)
  Top 0.305: v292.86,55.88 295.15,58.17 295.15,63.25 304.8,72.9 v304.8,75.95 | v291.59,101.6 291.59,103.12 299.47,111 301.24,111 302.51,112.27 A01.J1 | v208.79,32.26 208.79,33.02 213.61,37.85 218.19,37.85 v222.76,42.42 | v306.32,31.5 306.32,31.24 294.39,19.3 290.32,19.3 v282.45,11.43 | v231.65,25.91 231.65,27.43 229.62,29.46 218.19,18.03 218.19,17.02 209.8,8.64 209.8,7.11 v209.04,6.35 | v183.64,25.15 180.85,25.15 v179.32,23.62
  2 0.305: v179.32,23.62 185.67,17.27 191.26,22.86 192.28,22.86 194.56,25.15 199.9,25.15 200.66,25.91 201.68,25.91 207.26,31.5 208.03,31.5 v208.79,32.26 | v222.76,42.42 226.31,42.42 B07.J1
  Bottom 0.305: v292.86,55.88 302.77,45.97 302.77,43.43 B01.J1 303.53,42.16 303.53,38.1 304.55,37.08 304.55,33.27 v306.32,31.5 | v304.8,75.95 304.8,83.82 295.4,93.22 295.4,97.79 v291.59,101.6 | v179.32,23.62 173.23,29.72 170.43,29.72 B11.N2 | v282.45,11.43 272.8,1.78 263.4,1.78 260.1,5.08 258.06,5.08 257.3,5.84 255.27,5.84 244.09,17.02 242.06,17.02 233.93,25.15 232.92,25.15 232.41,25.65 231.9,25.65 v231.65,25.91 | v209.04,6.35 208.53,6.35 199.14,15.75 196.09,15.75 195.83,16 194.82,16 190.75,20.07 188.72,20.07 v183.64,25.15
P_BAC05  (via drill 0.61)
  Top 0.305: v187.71,2.29 190.75,2.29 223.27,34.8 225.04,34.8 226.31,36.07 B07.L1 227.58,37.08 227.58,39.12 235.97,47.5 236.47,47.5 v236.73,47.75 | v276.61,70.36 277.62,70.36 299.21,91.95 299.21,92.96 300.74,94.49 300.74,95.5 301.5,96.27 301.5,104.39 302.77,105.66 A01.L1 | v229.87,56.39 244.35,70.87 244.86,70.87 248.67,74.68 248.67,76.2 249.43,76.96 251.21,76.96 v256.79,82.55
  2 0.305: v266.7,64.77 268.73,62.74 275.34,69.34 275.59,69.34 v276.61,70.36
  15 0.305: v266.7,64.77 269.24,62.23 269.24,61.21 286,44.45 286,39.12 291.08,34.04 294.89,37.85 297.43,37.85 298.45,36.83 302.51,36.83 B01.L1
  Bottom 0.305: v187.71,2.29 176.78,13.21 174.5,13.21 173.74,13.97 B11.U2 | v236.73,47.75 236.73,50.29 235.46,51.56 234.95,51.56 230.12,56.39 v229.87,56.39 | v256.79,82.55 261.62,82.55 262.38,81.79 262.38,81.28 269.75,73.91 271.78,73.91 273.05,72.64 274.32,72.64 v276.61,70.36
P_BAC06  (via drill 0.61)
  Top 0.305: v203.2,52.07 200.15,52.07 199.14,51.05 193.8,51.05 191.26,48.51 190.25,48.51 180.09,38.35 177.8,38.35 v177.55,38.1 | v272.8,138.68 270.26,141.22 253.49,141.22 253.24,140.97 246.89,140.97 243.33,137.41 242.06,137.41 219.71,115.06 218.69,115.06 208.53,104.9 207.77,104.9 206.5,103.63 206.5,101.6 204.47,99.57 204.47,98.55 197.1,91.19 197.1,87.63 196.6,87.12 196.6,85.34 193.04,81.79 193.04,78.49 v191.26,76.71
  2 0.305: v267.72,5.84 269.24,7.37 271.27,7.37 292.61,28.7 297.43,28.7 299.21,30.48 300.48,30.48 302.77,32.77 305.82,32.77 B01.M1
  15 0.305: v267.72,5.84 260.6,5.84 249.68,16.76 249.68,18.29 242.82,25.15 240.28,25.15 233.93,31.5 232.41,31.5 230.89,33.02 B07.M1 | v272.8,138.68 276.86,134.62 278.64,134.62 302.26,111 302.26,109.22 306.07,105.41 306.07,103.89 A01.M1 | v191.26,76.71 191.26,67.82 202.95,56.13 202.95,52.32 v203.2,52.07
  Bottom 0.305: v203.2,52.07 207.77,47.5 211.58,47.5 222.25,36.83 223.52,36.83 226.57,33.78 229.62,33.78 B07.M1 | v177.55,38.1 170.18,38.1 164.08,44.2 162.56,44.2 161.04,45.72 B12.H2
P_BAC07  (via drill 0.61)
  Top 0.305: v210.82,8.13 213.36,8.13 218.95,13.72 218.95,17.78 226.31,25.15 228.35,25.15 B07.P1 | v262.89,3.81 263.65,4.57 264.92,4.57 267.72,7.37 271.27,7.37 271.53,7.62 274.83,7.62 276.1,8.89 278.64,8.89 279.4,9.65 284.73,9.65 293.62,18.54 294.64,18.54 302.51,26.42 305.82,26.42 B01.P1 | v304.55,59.69 304.04,59.69 300.99,56.64 300.99,55.88 v296.16,51.05
  2 0.305: v297.18,68.83 301.75,73.41 301.75,75.44 304.29,77.98 301.75,80.52 301.75,87.88 305.82,91.95 305.82,96.27 A01.P1
  15 0.305: v210.82,8.13 209.3,9.65 207.52,9.65 195.58,21.59 194.56,21.59 187.45,28.7 163.07,28.7 162.05,29.72 157.73,29.72 B12.N2 | v262.89,3.81 262.13,3.05 260.1,5.08 258.32,5.08 v255.52,7.87
  Bottom 0.305: v255.52,7.87 255.52,9.91 246.63,18.8 241.3,18.8 234.19,25.91 233.17,25.91 232.16,26.92 230.89,26.92 B07.P1 | v297.18,68.83 297.69,68.83 299.97,66.55 300.48,66.55 304.55,62.48 v304.55,59.69 | v296.16,51.05 294.13,49.02 300.99,42.16 300.99,40.64 301.5,40.13 301.5,33.78 304.55,30.73 304.55,29.21 306.07,27.69 B01.P1
P_BAC08  (via drill 0.61)
  Top 0.305: v261.37,2.29 261.87,2.79 263.4,2.79 264.41,3.81 274.83,3.81 275.84,4.83 284.23,4.83 288.29,8.89 291.34,8.89 295.4,12.95 300.74,12.95 305.82,18.03 305.82,20.07 B01.S1 | v289.56,65.79 301.75,77.98 301.75,81.53 304.29,84.07 304.29,85.09 305.31,86.11 305.31,88.9 305.82,89.41 305.82,89.92 A01.S1
  2 0.305: v187.96,38.86 163.83,14.73 161.04,14.73 B12.U2 | v303.28,51.05 303.02,51.05 301.75,49.78 301.75,33.02 300.48,31.75 v300.23,31.75
  15 0.305: v247.14,12.45 240.28,12.45 233.93,18.8 232.41,18.8 230.89,20.32 B07.S1
  Bottom 0.305: v187.96,38.86 191.01,38.86 191.52,38.35 197.87,38.35 210.57,25.65 218.44,25.65 218.69,25.4 222.25,25.4 223.27,24.38 224.54,24.38 226.57,22.35 228.35,22.35 229.62,21.08 B07.S1 | v261.37,2.29 257.3,2.29 v247.14,12.45 | v289.56,65.79 298.96,56.39 298.96,55.37 v303.28,51.05 | v300.23,31.75 300.23,28.7 304.55,24.38 304.55,22.86 306.07,21.34 B01.S1
P_BAC09  (via drill 0.61)
  Top 0.305: v305.31,70.61 303.78,69.09 303.78,66.8 303.02,66.04 303.02,64.01 297.43,58.42 297.43,56.13 B01.D2 | v185.93,82.3 150.11,46.48 148.34,46.48 B13.H2 | v280.16,74.68 279.4,74.68 v275.08,70.36 | v261.37,75.18 261.37,74.68 259.59,72.9 259.08,72.9 v252.48,66.29
  2 0.305: v296.42,95.25 297.43,96.27 297.43,98.55 298.2,99.31 298.2,103.38 302.51,107.7 305.31,107.7 v305.56,107.95 | v275.08,70.36 272.8,70.36 v271.27,68.83 | v242.06,76.71 241.3,75.95 239.52,75.95 231.39,67.82 230.89,67.82 222.5,59.44 222.5,57.4 B07.D2
  15 0.305: v305.31,70.61 305.31,73.91 301.75,77.47 301.75,79.5 300.99,80.26 300.99,81.28 298.7,83.57 298.7,89.92 295.4,93.22 295.4,94.23 v296.42,95.25 | v280.16,74.68 280.92,73.91 280.92,72.64 286,67.56 286,64.52 287.53,62.99 289.05,64.52 290.83,64.52 296.42,58.93 296.42,56.13 B01.D2
  Bottom 0.305: v305.56,107.95 305.56,108.46 305.05,108.97 305.05,111.25 307.09,113.28 298.7,121.67 298.7,123.19 297.18,124.71 A01.D2 | v185.93,82.3 190.75,82.3 194.31,78.74 194.82,78.74 196.6,76.96 197.36,76.96 216.92,57.4 218.44,57.4 219.96,55.88 B07.D2 | v271.27,68.83 270.76,68.83 265.68,73.91 263.65,73.91 262.89,74.68 261.87,74.68 v261.37,75.18 | v242.06,76.71 v252.48,66.29
P_BAC10  (via drill 0.61)
  Top 0.305: 285.24,64.77 284.99,65.02 v298.7,78.74 | 285.24,64.77 v289.81,60.2 | v279.65,101.09 280.92,101.09 291.85,112.01 291.85,116.08 296.16,120.4 298.2,120.4 A01.E2 | 285.24,64.77 284.99,64.77 276.61,56.39 274.32,56.39 256.29,38.35 255.27,38.35 v255.02,38.1
  2 0.305: v207.01,63.25 205.74,61.98 204.98,61.98 196.85,53.85 191.52,53.85 188.98,51.31 187.96,51.31 187.2,50.55 181.86,50.55 166.88,35.56 165.86,35.56 163.32,33.02 162.31,33.02 160.78,31.5 150.11,31.5 149.35,30.73 145.03,30.73 B13.N2
  15 0.305: v289.81,60.2 290.07,60.2 297.43,52.83 299.47,52.83 B01.E2 | v207.01,63.25 210.06,63.25 210.31,62.99 211.33,62.99 220.22,54.1 222,54.1 223.27,52.83 B07.E2 224.54,52.07 226.06,50.55 227.58,50.55 233.43,44.7 236.73,44.7 236.98,44.45 238,45.47 240.28,45.47 241.55,44.2 246.63,44.2 251.71,39.12 252.73,39.12 253.75,38.1 v255.02,38.1
  Bottom 0.305: v298.7,78.74 297.18,78.74 284.73,91.19 284.73,91.44 283.97,92.2 283.72,92.2 282.7,93.22 282.7,98.04 v279.65,101.09
P_BAC11  (via drill 0.61)
  Top 0.305: v154.18,19.05 154.18,18.8 150.11,14.73 148.34,14.73 B13.U2 | v183.13,44.45 183.13,47.5 184.66,49.02 185.67,49.02 191.26,54.61 192.28,54.61 v196.6,58.93 | v219.2,45.72 223.27,45.72 B07.H2 | v306.32,86.87 306.32,86.11 305.05,84.84 305.05,78.74 292.35,66.04 292.35,65.53 v290.32,63.5 | v302.77,47.5 301.75,47.5 300.74,46.48 B01.H2
  2 0.305: v154.18,19.05 156.72,19.05 162.81,25.15 166.88,25.15 183.9,42.16 183.9,43.69 v183.13,44.45 | v270.76,8.38 298.7,36.32 298.7,40.39 298.96,40.64 298.96,42.16 299.47,42.67 299.47,45.47 B01.H2
  15 0.305: v305.05,101.85 305.05,99.31 v304.8,99.06
  Bottom 0.305: v196.6,58.93 199.64,61.98 216.92,44.7 218.19,44.7 v219.2,45.72 | v270.76,8.38 265.94,8.38 256.54,17.78 255.78,17.78 253.24,20.32 252.48,20.32 240.03,32.77 239.01,32.77 227.58,44.2 226.06,44.2 224.54,45.72 B07.H2 | v305.05,101.85 304.55,102.36 304.55,106.93 300.48,111 300.48,115.32 A01.H2 | v304.8,99.06 304.8,88.39 v306.32,86.87 | v290.32,63.5 290.83,63.5 298.2,56.13 298.2,52.07 v302.77,47.5
P_BREAK  (via drill 0.61)
  Top 0.305: B23.V2 18.03,10.67 23.37,5.33 29.46,11.43 B22.V2 | v248.92,8.13 251.46,8.13 260.1,16.76 260.1,25.15 B04.P2
  2 0.305: v121.41,2.79 128.27,9.65 132.33,9.65 134.37,11.68 134.37,13.72 B14.U2 135.64,13.97 139.45,13.97 141.48,11.94 141.73,12.19 143.51,12.19 143.76,12.45 168.15,12.45 169.42,13.72 170.43,13.72 172.47,15.75 185.17,15.75 191.52,22.1 196.85,22.1 197.61,22.86 198.63,22.86 200.91,25.15 206.25,25.15 207.01,25.91 208.03,25.91 210.57,28.45 222.25,28.45 223.27,27.43 B07.P2
  15 0.305: v287.02,60.96 284.73,63.25 284.23,63.25 282.45,65.02 282.45,70.1 275.84,76.71 275.84,78.99 274.07,80.77 274.07,81.28 262.38,92.96 262.38,96.27 A04.P2 | v299.97,41.66 304.55,37.08 304.55,35.81 302.01,33.27 300.48,34.8 297.18,34.8 276.61,14.22 265.68,25.15 264.16,25.15 262.64,26.67 B04.P2
  Bottom 0.305: v121.41,2.79 31.24,2.79 29.46,4.57 24.13,4.57 18.03,10.67 B23.V2 | v248.92,8.13 247.4,9.65 245.62,9.65 236.73,18.54 235.46,18.54 227.33,26.67 224.54,26.67 B07.P2 | v287.02,60.96 291.85,56.13 291.85,49.78 v299.97,41.66
P_BRKRQ  (via drill 0.61)
  2 0.305: 172.21,81.28 197.36,106.43 197.36,106.68 197.87,107.19 199.14,107.19 216.92,124.97 218.19,124.97 226.31,133.1 v234.7,133.1 | 172.21,81.28 156.72,65.79 156.72,64.77 114.05,22.1 96.27,22.1 94.74,20.57 85.6,29.72 81.53,29.72 B18.N2 | v228.6,13.21 228.85,12.95 230.89,12.95 239.01,21.08 240.03,21.08 241.3,22.35 246.63,22.35 249.17,24.89 250.19,24.89 252.48,27.18 252.98,27.18 261.37,35.56 261.37,39.12 B04.K2 | v172.97,80.52 172.21,81.28
  15 0.305: v234.7,133.1 241.81,133.1 248.67,126.24 248.67,125.22 258.83,115.06 258.83,114.55 260.1,113.28 260.1,111.76 261.62,110.24 A04.K2 | v228.6,13.21 227.58,13.21 226.31,14.48 226.31,16.26 216.15,26.42 216.15,32.77 212.85,36.07 212.85,39.88 186.18,66.55 185.67,66.55 173.23,78.99 173.23,80.26 v172.97,80.52
P_CAINCR  (via drill 0.61)
  Top 0.305: v146.81,86.87 147.32,86.87 159.51,99.06 160.53,99.06 165.86,104.39 165.86,105.66 v203.45,143.26 | v238,42.42 235.2,42.42 v231.14,38.35
  2 0.305: v146.81,86.87 142.24,82.3 131.06,82.3 112.78,64.01 111.76,64.01 111,63.25 105.66,63.25 86.61,44.2 73.91,44.2 73.15,43.43 68.83,43.43 B19.J2 | v231.14,38.35 229.11,38.35 226.82,40.64 224.54,38.35 216.92,38.35 v214.12,41.15
  Bottom 0.305: v203.45,143.26 204.22,143.26 206.5,140.97 207.01,140.97 238,109.98 239.27,109.98 240.28,108.97 241.55,108.97 245.62,104.9 247.4,104.9 248.67,103.63 A05.M2 | v238,42.42 239.27,41.15 243.33,41.15 247.65,36.83 247.65,34.8 248.67,33.78 B05.M2 | v214.12,41.15 212.6,41.15 178.05,75.69 174.24,75.69 172.47,77.47 166.88,77.47 166.62,77.72 164.85,77.72 154.43,88.14 151.89,88.14 151.38,88.65 148.59,88.65 v146.81,86.87
P_DATA00  (via drill 0.61)
  Top 0.305: v136.65,134.62 113.03,111 96.27,111 93.73,108.46 92.71,108.46 88.9,104.65 83.57,104.65 74.68,95.76 73.66,95.76 71.37,93.47 70.36,93.47 41.91,65.02 41.91,64.26 33.78,56.13 30.73,56.13 B22.D2
  2 0.305: v158.5,133.35 174.75,133.35 178.56,137.16 193.29,137.16 v196.34,140.21 | v236.98,113.54 237.74,113.54 247.14,122.94 247.14,123.7 248.67,125.22 248.67,125.98 250.7,128.02 250.7,129.79 251.97,131.06 A05.B1 | v259.08,73.91 253.49,68.33 253.49,64.26 252.98,63.75 252.98,62.48 B05.B1
  15 0.305: v196.34,140.21 197.36,141.22 198.88,139.7 201.17,139.7 201.42,139.45 208.53,139.45 214.88,133.1 215.39,133.1 230.89,117.6 232.92,117.6 v236.98,113.54 238.76,111.76 238.76,110.49 241.55,107.7 241.55,102.62 242.57,101.6 241.55,100.58 241.55,96.27 242.82,95 v241.3,93.47 | v259.08,73.91 259.08,75.95 256.29,78.74 v256.03,78.74
  Bottom 0.305: v136.65,134.62 139.7,134.62 140.72,133.6 158.24,133.6 v158.5,133.35 | v256.03,78.74 256.03,79.25 243.33,91.95 242.82,91.95 v241.3,93.47
P_DATA01  (via drill 0.61)
  Top 0.305: v233.17,28.45 233.68,28.45 v243.33,38.1 | v238.76,120.4 242.32,123.95 246.63,123.95 247.4,124.71 248.16,124.71 248.41,124.97 251.71,124.97 A05.D1 | v217.17,85.85 216.15,84.84 216.15,80.52 212.6,76.96 212.6,74.93 203.45,65.79 203.45,60.45 196.09,53.09 v196.09,52.83
  2 0.305: v109.47,6.35 122.68,6.35 128.52,12.19 130.81,12.19 134.37,15.75 147.07,15.75 162.81,31.5 168.66,31.5 v185.17,48.01 | v230.12,123.95 229.11,123.95 224.28,119.13 224.28,118.36 222.5,116.59 222.5,112.52 208.79,98.81 208.79,96.27 v207.77,95.25
  15 0.305: v243.33,38.1 246.13,40.89 248.67,38.35 252.48,38.35 253.49,37.34 254.25,37.34 254.51,37.08 255.78,37.08 261.87,43.18 259.59,45.47 259.59,46.48 254.25,51.82 254.25,53.34 252.73,54.86 B05.D1
  Bottom 0.305: v109.47,6.35 103.89,6.35 101.35,8.89 99.31,8.89 98.55,9.65 93.22,9.65 89.92,12.95 83.57,12.95 80.52,16 74.17,16 68.58,21.59 67.56,21.59 63.5,25.65 58.17,25.65 56.39,27.43 55.37,27.43 34.04,48.77 30.73,48.77 B22.F2 | v185.17,48.01 192.53,55.37 194.56,53.34 195.58,53.34 v196.09,52.83 216.92,32 223.27,32 226.57,28.7 232.92,28.7 v233.17,28.45 | v238.76,120.4 238.76,121.92 236.98,123.7 230.38,123.7 v230.12,123.95 | v207.77,95.25 208.28,95.25 215.65,87.88 215.65,87.38 v217.17,85.85
P_DATA02  (via drill 0.61)
  Top 0.305: v164.34,141.48 162.31,143.51 156.72,143.51 149.61,136.4 147.07,136.4 143.76,133.1 137.41,133.1 135.13,130.81 134.11,130.81 111,107.7 92.96,107.7 77.22,91.95 70.87,91.95 69.6,90.68 69.6,86.61 67.31,84.33 67.31,83.31 57.66,73.66 57.66,72.39 30.73,45.47 30.73,43.43 B22.J2 | v234.7,141.22 234.44,141.22 217.42,124.21 v217.42,123.95 217.17,123.95 212.34,119.13 v212.34,117.6 | v207.01,97.54 205.23,99.31 v217.17,111.25
  2 0.305: v248.16,60.2 247.9,60.2 v246.13,58.42
  15 0.305: v164.34,141.48 177.29,141.48 185.17,133.6 197.87,133.6 207.52,123.95 v217.42,123.95 | v248.16,60.2 249.68,60.2 255.27,54.61 255.27,53.09 B05.E1
  Bottom 0.305: v234.7,141.22 238.51,141.22 253.75,125.98 253.75,124.46 255.27,122.94 A05.E1 | v207.01,97.54 v246.13,58.42 | v217.17,111.25 217.17,112.78 v212.34,117.6
P_DATA03  (via drill 0.61)
  Top 0.305: v219.2,82.8 219.2,82.04 v213.61,76.45
  2 0.305: v67.56,15.24 70.36,15.24 70.87,15.75 86.11,15.75 91.19,10.67 92.96,12.45 105.66,12.45 134.37,41.15 139.7,41.15 165.61,67.06 165.61,71.88 v172.21,78.49 | v185.67,70.87 187.96,70.87 196.85,79.76 199.39,79.76 202.95,76.2 205.74,78.99 208.28,78.99 v208.79,79.5 | v251.21,45.72 255.02,45.72 B05.H1 | v239.52,117.35 234.7,117.35 234.19,116.84 233.68,116.84 230.89,114.05 230.89,112.27 219.2,100.58 219.2,100.08 v217.68,98.55
  15 0.305: v239.52,117.35 242.82,114.05 246.63,114.05 247.4,113.28 248.16,113.28 249.17,112.27 249.68,112.27 250.95,111 256.03,111 257.3,112.27 257.3,113.03 257.56,113.28 257.56,115.06 257.05,115.57 256.29,115.57 A05.H1 | v217.68,98.55 218.95,97.28 218.95,90.93 222,87.88 222,85.6 v219.2,82.8